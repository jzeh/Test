<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\03_Record.ewp</path>
    </project>
    <batchBuild />
</workspace>
