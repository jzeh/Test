<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>02_Diagnosis</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>261</archiveVersion>
            <data>
                <version>261</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs></extraArgs>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>1</enableParallel>
                    <parallelThreads>6</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>1.5.4</cstat_version>
                    <checks_tree>
                        <package name="STDCHECKS" enabled="true">
                            <group enabled="true" name="ARR">
                                <check name="ARR-inv-index-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr" enabled="true" />
                                <check name="ARR-inv-index" enabled="true" />
                                <check name="ARR-neg-index" enabled="true" />
                                <check name="ARR-uninit-index" enabled="true" />
                            </group>
                            <group enabled="true" name="ATH">
                                <check name="ATH-cmp-float" enabled="true" />
                                <check name="ATH-cmp-unsign-neg" enabled="true" />
                                <check name="ATH-cmp-unsign-pos" enabled="true" />
                                <check name="ATH-div-0-assign" enabled="true" />
                                <check name="ATH-div-0-cmp-aft" enabled="false" />
                                <check name="ATH-div-0-cmp-bef" enabled="true" />
                                <check name="ATH-div-0-interval" enabled="true" />
                                <check name="ATH-div-0-pos" enabled="true" />
                                <check name="ATH-div-0-unchk-global" enabled="true" />
                                <check name="ATH-div-0-unchk-local" enabled="true" />
                                <check name="ATH-div-0-unchk-param" enabled="true" />
                                <check name="ATH-div-0" enabled="true" />
                                <check name="ATH-inc-bool" enabled="true" />
                                <check name="ATH-malloc-overrun" enabled="true" />
                                <check name="ATH-neg-check-nonneg" enabled="true" />
                                <check name="ATH-neg-check-pos" enabled="true" />
                                <check name="ATH-new-overrun" enabled="true" />
                                <check name="ATH-overflow-cast" enabled="false" />
                                <check name="ATH-overflow" enabled="true" />
                                <check name="ATH-shift-bounds" enabled="true" />
                                <check name="ATH-shift-neg" enabled="true" />
                                <check name="ATH-sizeof-by-sizeof" enabled="true" />
                            </group>
                            <group enabled="true" name="CAST">
                                <check name="CAST-old-style" enabled="false" />
                            </group>
                            <group enabled="true" name="CATCH">
                                <check name="CATCH-object-slicing" enabled="true" />
                                <check name="CATCH-xtor-bad-member" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMA">
                                <check name="COMMA-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMENT">
                                <check name="COMMENT-nested" enabled="true" />
                            </group>
                            <group enabled="true" name="CONST">
                                <check name="CONST-member-ret" enabled="true" />
                            </group>
                            <group enabled="true" name="COP">
                                <check name="COP-alloc-ctor" enabled="false" />
                                <check name="COP-assign-op-ret" enabled="true" />
                                <check name="COP-assign-op-self" enabled="true" />
                                <check name="COP-assign-op" enabled="true" />
                                <check name="COP-copy-ctor" enabled="true" />
                                <check name="COP-dealloc-dtor" enabled="false" />
                                <check name="COP-dtor-throw" enabled="true" />
                                <check name="COP-dtor" enabled="true" />
                                <check name="COP-init-order" enabled="true" />
                                <check name="COP-init-uninit" enabled="true" />
                                <check name="COP-member-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="CPU">
                                <check name="CPU-ctor-call-virt" enabled="true" />
                                <check name="CPU-ctor-implicit" enabled="false" />
                                <check name="CPU-delete-throw" enabled="true" />
                                <check name="CPU-delete-void" enabled="true" />
                                <check name="CPU-dtor-call-virt" enabled="true" />
                                <check name="CPU-malloc-class" enabled="true" />
                                <check name="CPU-nonvirt-dtor" enabled="true" />
                                <check name="CPU-return-ref-to-class-data" enabled="true" />
                            </group>
                            <group enabled="true" name="DECL">
                                <check name="DECL-implicit-int" enabled="false" />
                            </group>
                            <group enabled="true" name="DEFINE">
                                <check name="DEFINE-hash-multiple" enabled="true" />
                            </group>
                            <group enabled="true" name="ENUM">
                                <check name="ENUM-bounds" enabled="false" />
                            </group>
                            <group enabled="true" name="EXP">
                                <check name="EXP-cond-assign" enabled="true" />
                                <check name="EXP-dangling-else" enabled="true" />
                                <check name="EXP-loop-exit" enabled="true" />
                                <check name="EXP-main-ret-int" enabled="false" />
                                <check name="EXP-null-stmt" enabled="false" />
                                <check name="EXP-stray-semicolon" enabled="false" />
                            </group>
                            <group enabled="true" name="EXPR">
                                <check name="EXPR-const-overflow" enabled="true" />
                            </group>
                            <group enabled="true" name="FPT">
                                <check name="FPT-cmp-null" enabled="true" />
                                <check name="FPT-literal" enabled="false" />
                                <check name="FPT-misuse" enabled="true" />
                            </group>
                            <group enabled="true" name="FUNC">
                                <check name="FUNC-implicit-decl" enabled="false" />
                                <check name="FUNC-unprototyped-all" enabled="false" />
                                <check name="FUNC-unprototyped-used" enabled="true" />
                            </group>
                            <group enabled="true" name="INCLUDE">
                                <check name="INCLUDE-c-file" enabled="false" />
                            </group>
                            <group enabled="true" name="INT">
                                <check name="INT-use-signed-as-unsigned-pos" enabled="false" />
                                <check name="INT-use-signed-as-unsigned" enabled="true" />
                            </group>
                            <group enabled="true" name="ITR">
                                <check name="ITR-end-cmp-aft" enabled="true" />
                                <check name="ITR-end-cmp-bef" enabled="true" />
                                <check name="ITR-invalidated" enabled="true" />
                                <check name="ITR-mismatch-alg" enabled="false" />
                                <check name="ITR-store" enabled="false" />
                                <check name="ITR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="LIB">
                                <check name="LIB-bsearch-overrun-pos" enabled="false" />
                                <check name="LIB-bsearch-overrun" enabled="false" />
                                <check name="LIB-fn-unsafe" enabled="false" />
                                <check name="LIB-fread-overrun-pos" enabled="false" />
                                <check name="LIB-fread-overrun" enabled="true" />
                                <check name="LIB-memchr-overrun-pos" enabled="false" />
                                <check name="LIB-memchr-overrun" enabled="true" />
                                <check name="LIB-memcpy-overrun-pos" enabled="false" />
                                <check name="LIB-memcpy-overrun" enabled="true" />
                                <check name="LIB-memset-overrun-pos" enabled="false" />
                                <check name="LIB-memset-overrun" enabled="true" />
                                <check name="LIB-putenv" enabled="false" />
                                <check name="LIB-qsort-overrun-pos" enabled="false" />
                                <check name="LIB-qsort-overrun" enabled="false" />
                                <check name="LIB-return-const" enabled="true" />
                                <check name="LIB-return-error" enabled="true" />
                                <check name="LIB-return-leak" enabled="true" />
                                <check name="LIB-return-neg" enabled="true" />
                                <check name="LIB-return-null" enabled="true" />
                                <check name="LIB-sprintf-overrun" enabled="false" />
                                <check name="LIB-std-sort-overrun-pos" enabled="false" />
                                <check name="LIB-std-sort-overrun" enabled="true" />
                                <check name="LIB-strcat-overrun-pos" enabled="false" />
                                <check name="LIB-strcat-overrun" enabled="true" />
                                <check name="LIB-strcpy-overrun-pos" enabled="false" />
                                <check name="LIB-strcpy-overrun" enabled="true" />
                                <check name="LIB-strncat-overrun-pos" enabled="false" />
                                <check name="LIB-strncat-overrun" enabled="true" />
                                <check name="LIB-strncmp-overrun-pos" enabled="false" />
                                <check name="LIB-strncmp-overrun" enabled="true" />
                                <check name="LIB-strncpy-overrun-pos" enabled="false" />
                                <check name="LIB-strncpy-overrun" enabled="true" />
                            </group>
                            <group enabled="true" name="LOGIC">
                                <check name="LOGIC-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="MEM">
                                <check name="MEM-delete-array-op" enabled="true" />
                                <check name="MEM-delete-op" enabled="true" />
                                <check name="MEM-double-free-alias" enabled="true" />
                                <check name="MEM-double-free-some" enabled="true" />
                                <check name="MEM-double-free" enabled="true" />
                                <check name="MEM-free-field" enabled="true" />
                                <check name="MEM-free-fptr" enabled="true" />
                                <check name="MEM-free-no-alloc-struct" enabled="false" />
                                <check name="MEM-free-no-alloc" enabled="false" />
                                <check name="MEM-free-no-use" enabled="true" />
                                <check name="MEM-free-op" enabled="true" />
                                <check name="MEM-free-struct-field" enabled="true" />
                                <check name="MEM-free-variable-alias" enabled="true" />
                                <check name="MEM-free-variable" enabled="true" />
                                <check name="MEM-leak-alias" enabled="true" />
                                <check name="MEM-leak" enabled="false" />
                                <check name="MEM-malloc-arith" enabled="false" />
                                <check name="MEM-malloc-diff-type" enabled="true" />
                                <check name="MEM-malloc-sizeof-ptr" enabled="true" />
                                <check name="MEM-malloc-sizeof" enabled="true" />
                                <check name="MEM-malloc-strlen" enabled="false" />
                                <check name="MEM-realloc-diff-type" enabled="true" />
                                <check name="MEM-return-free" enabled="true" />
                                <check name="MEM-return-no-assign" enabled="true" />
                                <check name="MEM-stack-global-field" enabled="true" />
                                <check name="MEM-stack-global" enabled="true" />
                                <check name="MEM-stack-param-ref" enabled="true" />
                                <check name="MEM-stack-param" enabled="true" />
                                <check name="MEM-stack-pos" enabled="true" />
                                <check name="MEM-stack-ref" enabled="true" />
                                <check name="MEM-stack" enabled="true" />
                                <check name="MEM-use-free-all" enabled="true" />
                                <check name="MEM-use-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="PTR">
                                <check name="PTR-arith-field" enabled="true" />
                                <check name="PTR-arith-stack" enabled="true" />
                                <check name="PTR-arith-var" enabled="true" />
                                <check name="PTR-cmp-str-lit" enabled="true" />
                                <check name="PTR-null-assign-fun-pos" enabled="false" />
                                <check name="PTR-null-assign-pos" enabled="false" />
                                <check name="PTR-null-assign" enabled="true" />
                                <check name="PTR-null-cmp-aft" enabled="true" />
                                <check name="PTR-null-cmp-bef-fun" enabled="true" />
                                <check name="PTR-null-cmp-bef" enabled="true" />
                                <check name="PTR-null-fun-pos" enabled="true" />
                                <check name="PTR-null-literal-pos" enabled="false" />
                                <check name="PTR-overload" enabled="false" />
                                <check name="PTR-singleton-arith-pos" enabled="false" />
                                <check name="PTR-singleton-arith" enabled="true" />
                                <check name="PTR-unchk-param-some" enabled="true" />
                                <check name="PTR-unchk-param" enabled="false" />
                                <check name="PTR-uninit-pos" enabled="false" />
                                <check name="PTR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="RED">
                                <check name="RED-alloc-zero-bytes" enabled="false" />
                                <check name="RED-case-reach" enabled="false" />
                                <check name="RED-cmp-always" enabled="false" />
                                <check name="RED-cmp-never" enabled="false" />
                                <check name="RED-cond-always" enabled="false" />
                                <check name="RED-cond-const-assign" enabled="true" />
                                <check name="RED-cond-const-expr" enabled="false" />
                                <check name="RED-cond-const" enabled="false" />
                                <check name="RED-cond-never" enabled="false" />
                                <check name="RED-dead" enabled="true" />
                                <check name="RED-expr" enabled="false" />
                                <check name="RED-func-no-effect" enabled="false" />
                                <check name="RED-local-hides-global" enabled="true" />
                                <check name="RED-local-hides-local" enabled="false" />
                                <check name="RED-local-hides-member" enabled="false" />
                                <check name="RED-local-hides-param" enabled="true" />
                                <check name="RED-no-effect" enabled="false" />
                                <check name="RED-self-assign" enabled="true" />
                                <check name="RED-unused-assign" enabled="true" />
                                <check name="RED-unused-param" enabled="false" />
                                <check name="RED-unused-return-val" enabled="false" />
                                <check name="RED-unused-val" enabled="false" />
                                <check name="RED-unused-var-all" enabled="true" />
                            </group>
                            <group enabled="true" name="RESOURCE">
                                <check name="RESOURCE-deref-file" enabled="false" />
                                <check name="RESOURCE-double-close" enabled="true" />
                                <check name="RESOURCE-file-no-close-all" enabled="true" />
                                <check name="RESOURCE-file-pos-neg" enabled="false" />
                                <check name="RESOURCE-file-use-after-close" enabled="true" />
                                <check name="RESOURCE-implicit-deref-file" enabled="false" />
                                <check name="RESOURCE-write-ronly-file" enabled="true" />
                            </group>
                            <group enabled="true" name="SIZEOF">
                                <check name="SIZEOF-side-effect" enabled="true" />
                            </group>
                            <group enabled="true" name="SPC">
                                <check name="SPC-order" enabled="true" />
                                <check name="SPC-uninit-arr-all" enabled="false" />
                                <check name="SPC-uninit-struct-field-heap" enabled="true" />
                                <check name="SPC-uninit-struct-field" enabled="false" />
                                <check name="SPC-uninit-struct" enabled="true" />
                                <check name="SPC-uninit-var-all" enabled="true" />
                                <check name="SPC-uninit-var-some" enabled="true" />
                                <check name="SPC-volatile-reads" enabled="false" />
                                <check name="SPC-volatile-writes" enabled="false" />
                            </group>
                            <group enabled="true" name="STRUCT">
                                <check name="STRUCT-signed-bit" enabled="false" />
                            </group>
                            <group enabled="true" name="SWITCH">
                                <check name="SWITCH-fall-through" enabled="true" />
                            </group>
                            <group enabled="true" name="THROW">
                                <check name="THROW-empty" enabled="false" />
                                <check name="THROW-main" enabled="false" />
                                <check name="THROW-null" enabled="true" />
                                <check name="THROW-ptr" enabled="true" />
                                <check name="THROW-static" enabled="true" />
                                <check name="THROW-unhandled" enabled="true" />
                            </group>
                            <group enabled="true" name="UNION">
                                <check name="UNION-overlap-assign" enabled="true" />
                                <check name="UNION-type-punning" enabled="true" />
                            </group>
                        </package>
                        <package name="CERT" enabled="false">
                            <group enabled="true" name="CERT-EXP">
                                <check name="CERT-EXP19-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-FIO">
                                <check name="CERT-FIO37-C" enabled="true" />
                                <check name="CERT-FIO38-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-SIG">
                                <check name="CERT-SIG31-C" enabled="true" />
                            </group>
                        </package>
                        <package name="SECURITY" enabled="false">
                            <group enabled="true" name="SEC-BUFFER">
                                <check name="SEC-BUFFER-memory-leak-alias" enabled="true" />
                                <check name="SEC-BUFFER-memory-leak" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun" enabled="true" />
                                <check name="SEC-BUFFER-qsort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-qsort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-sprintf-overrun" enabled="true" />
                                <check name="SEC-BUFFER-std-sort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-std-sort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncmp-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncmp-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-tainted-alloc-size" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy-length" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy" enabled="true" />
                                <check name="SEC-BUFFER-tainted-index" enabled="true" />
                                <check name="SEC-BUFFER-tainted-offset" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-all" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-DIV-0">
                                <check name="SEC-DIV-0-compare-after" enabled="true" />
                                <check name="SEC-DIV-0-compare-before" enabled="true" />
                                <check name="SEC-DIV-0-tainted" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-FILEOP">
                                <check name="SEC-FILEOP-open-no-close" enabled="true" />
                                <check name="SEC-FILEOP-path-traversal" enabled="false" />
                                <check name="SEC-FILEOP-use-after-close" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-INJECTION">
                                <check name="SEC-INJECTION-sql" enabled="false" />
                                <check name="SEC-INJECTION-xpath" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-LOOP">
                                <check name="SEC-LOOP-tainted-bound" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-NULL">
                                <check name="SEC-NULL-assignment-fun-pos" enabled="false" />
                                <check name="SEC-NULL-assignment" enabled="true" />
                                <check name="SEC-NULL-cmp-aft" enabled="true" />
                                <check name="SEC-NULL-cmp-bef-fun" enabled="true" />
                                <check name="SEC-NULL-cmp-bef" enabled="true" />
                                <check name="SEC-NULL-literal-pos" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-STRING">
                                <check name="SEC-STRING-format-string" enabled="true" />
                                <check name="SEC-STRING-hard-coded-credentials" enabled="false" />
                            </group>
                        </package>
                        <package name="MISRAC2004" enabled="false">
                            <group enabled="true" name="MISRAC2004-1">
                                <check name="MISRAC2004-1.1" enabled="true" />
                                <check name="MISRAC2004-1.2_a" enabled="true" />
                                <check name="MISRAC2004-1.2_b" enabled="true" />
                                <check name="MISRAC2004-1.2_c" enabled="true" />
                                <check name="MISRAC2004-1.2_d" enabled="true" />
                                <check name="MISRAC2004-1.2_e" enabled="true" />
                                <check name="MISRAC2004-1.2_f" enabled="true" />
                                <check name="MISRAC2004-1.2_g" enabled="true" />
                                <check name="MISRAC2004-1.2_h" enabled="true" />
                                <check name="MISRAC2004-1.2_i" enabled="true" />
                                <check name="MISRAC2004-1.2_j" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-2">
                                <check name="MISRAC2004-2.1" enabled="true" />
                                <check name="MISRAC2004-2.2" enabled="true" />
                                <check name="MISRAC2004-2.3" enabled="true" />
                                <check name="MISRAC2004-2.4" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-5">
                                <check name="MISRAC2004-5.2" enabled="true" />
                                <check name="MISRAC2004-5.3" enabled="true" />
                                <check name="MISRAC2004-5.4" enabled="true" />
                                <check name="MISRAC2004-5.5" enabled="false" />
                                <check name="MISRAC2004-5.6" enabled="false" />
                                <check name="MISRAC2004-5.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-6">
                                <check name="MISRAC2004-6.1" enabled="true" />
                                <check name="MISRAC2004-6.2" enabled="true" />
                                <check name="MISRAC2004-6.3" enabled="false" />
                                <check name="MISRAC2004-6.4" enabled="true" />
                                <check name="MISRAC2004-6.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-7">
                                <check name="MISRAC2004-7.1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8">
                                <check name="MISRAC2004-8.1" enabled="true" />
                                <check name="MISRAC2004-8.2" enabled="true" />
                                <check name="MISRAC2004-8.3" enabled="true" />
                                <check name="MISRAC2004-8.5_a" enabled="true" />
                                <check name="MISRAC2004-8.5_b" enabled="true" />
                                <check name="MISRAC2004-8.6" enabled="true" />
                                <check name="MISRAC2004-8.7" enabled="true" />
                                <check name="MISRAC2004-8.8_a" enabled="true" />
                                <check name="MISRAC2004-8.8_b" enabled="true" />
                                <check name="MISRAC2004-8.12" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8 10">
                                <check name="MISRAC2004-8.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-9">
                                <check name="MISRAC2004-9.1_a" enabled="true" />
                                <check name="MISRAC2004-9.1_b" enabled="true" />
                                <check name="MISRAC2004-9.1_c" enabled="true" />
                                <check name="MISRAC2004-9.2" enabled="true" />
                                <check name="MISRAC2004-9.3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-10">
                                <check name="MISRAC2004-10.1_a" enabled="true" />
                                <check name="MISRAC2004-10.1_b" enabled="true" />
                                <check name="MISRAC2004-10.1_c" enabled="true" />
                                <check name="MISRAC2004-10.1_d" enabled="true" />
                                <check name="MISRAC2004-10.2_a" enabled="true" />
                                <check name="MISRAC2004-10.2_b" enabled="true" />
                                <check name="MISRAC2004-10.2_c" enabled="true" />
                                <check name="MISRAC2004-10.2_d" enabled="true" />
                                <check name="MISRAC2004-10.3" enabled="true" />
                                <check name="MISRAC2004-10.4" enabled="true" />
                                <check name="MISRAC2004-10.5" enabled="true" />
                                <check name="MISRAC2004-10.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-11">
                                <check name="MISRAC2004-11.1" enabled="true" />
                                <check name="MISRAC2004-11.3" enabled="false" />
                                <check name="MISRAC2004-11.4" enabled="false" />
                                <check name="MISRAC2004-11.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-12">
                                <check name="MISRAC2004-12.1" enabled="false" />
                                <check name="MISRAC2004-12.2_a" enabled="true" />
                                <check name="MISRAC2004-12.2_b" enabled="true" />
                                <check name="MISRAC2004-12.2_c" enabled="true" />
                                <check name="MISRAC2004-12.3" enabled="true" />
                                <check name="MISRAC2004-12.4" enabled="true" />
                                <check name="MISRAC2004-12.5" enabled="true" />
                                <check name="MISRAC2004-12.6_a" enabled="false" />
                                <check name="MISRAC2004-12.6_b" enabled="false" />
                                <check name="MISRAC2004-12.7" enabled="true" />
                                <check name="MISRAC2004-12.8" enabled="true" />
                                <check name="MISRAC2004-12.9" enabled="true" />
                                <check name="MISRAC2004-12.10" enabled="true" />
                                <check name="MISRAC2004-12.11" enabled="false" />
                                <check name="MISRAC2004-12.12_a" enabled="true" />
                                <check name="MISRAC2004-12.12_b" enabled="true" />
                                <check name="MISRAC2004-12.13" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-13">
                                <check name="MISRAC2004-13.1" enabled="true" />
                                <check name="MISRAC2004-13.2_a" enabled="false" />
                                <check name="MISRAC2004-13.2_b" enabled="false" />
                                <check name="MISRAC2004-13.2_c" enabled="false" />
                                <check name="MISRAC2004-13.2_d" enabled="false" />
                                <check name="MISRAC2004-13.2_e" enabled="false" />
                                <check name="MISRAC2004-13.3" enabled="true" />
                                <check name="MISRAC2004-13.4" enabled="true" />
                                <check name="MISRAC2004-13.5" enabled="true" />
                                <check name="MISRAC2004-13.6" enabled="true" />
                                <check name="MISRAC2004-13.7_a" enabled="true" />
                                <check name="MISRAC2004-13.7_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-14">
                                <check name="MISRAC2004-14.1" enabled="true" />
                                <check name="MISRAC2004-14.2" enabled="true" />
                                <check name="MISRAC2004-14.3" enabled="true" />
                                <check name="MISRAC2004-14.4" enabled="true" />
                                <check name="MISRAC2004-14.5" enabled="true" />
                                <check name="MISRAC2004-14.6" enabled="true" />
                                <check name="MISRAC2004-14.7" enabled="true" />
                                <check name="MISRAC2004-14.8_a" enabled="true" />
                                <check name="MISRAC2004-14.8_b" enabled="true" />
                                <check name="MISRAC2004-14.8_c" enabled="true" />
                                <check name="MISRAC2004-14.8_d" enabled="true" />
                                <check name="MISRAC2004-14.9" enabled="true" />
                                <check name="MISRAC2004-14.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-15">
                                <check name="MISRAC2004-15.0" enabled="true" />
                                <check name="MISRAC2004-15.1" enabled="true" />
                                <check name="MISRAC2004-15.2" enabled="true" />
                                <check name="MISRAC2004-15.3" enabled="true" />
                                <check name="MISRAC2004-15.4" enabled="true" />
                                <check name="MISRAC2004-15.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-16">
                                <check name="MISRAC2004-16.1" enabled="true" />
                                <check name="MISRAC2004-16.2_a" enabled="true" />
                                <check name="MISRAC2004-16.2_b" enabled="true" />
                                <check name="MISRAC2004-16.3" enabled="true" />
                                <check name="MISRAC2004-16.4" enabled="true" />
                                <check name="MISRAC2004-16.5" enabled="true" />
                                <check name="MISRAC2004-16.7" enabled="true" />
                                <check name="MISRAC2004-16.8" enabled="true" />
                                <check name="MISRAC2004-16.9" enabled="true" />
                                <check name="MISRAC2004-16.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-17">
                                <check name="MISRAC2004-17.1_a" enabled="true" />
                                <check name="MISRAC2004-17.1_b" enabled="true" />
                                <check name="MISRAC2004-17.1_c" enabled="true" />
                                <check name="MISRAC2004-17.2" enabled="true" />
                                <check name="MISRAC2004-17.3" enabled="true" />
                                <check name="MISRAC2004-17.4_a" enabled="true" />
                                <check name="MISRAC2004-17.4_b" enabled="true" />
                                <check name="MISRAC2004-17.5" enabled="true" />
                                <check name="MISRAC2004-17.6_a" enabled="true" />
                                <check name="MISRAC2004-17.6_b" enabled="true" />
                                <check name="MISRAC2004-17.6_c" enabled="true" />
                                <check name="MISRAC2004-17.6_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-18">
                                <check name="MISRAC2004-18.1" enabled="true" />
                                <check name="MISRAC2004-18.2" enabled="true" />
                                <check name="MISRAC2004-18.4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-19">
                                <check name="MISRAC2004-19.1" enabled="false" />
                                <check name="MISRAC2004-19.2" enabled="false" />
                                <check name="MISRAC2004-19.4" enabled="true" />
                                <check name="MISRAC2004-19.5" enabled="true" />
                                <check name="MISRAC2004-19.6" enabled="true" />
                                <check name="MISRAC2004-19.7" enabled="false" />
                                <check name="MISRAC2004-19.10" enabled="true" />
                                <check name="MISRAC2004-19.12" enabled="true" />
                                <check name="MISRAC2004-19.13" enabled="false" />
                                <check name="MISRAC2004-19.15" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-20">
                                <check name="MISRAC2004-20.1" enabled="true" />
                                <check name="MISRAC2004-20.2" enabled="true" />
                                <check name="MISRAC2004-20.3_a" enabled="true" />
                                <check name="MISRAC2004-20.3_b" enabled="true" />
                                <check name="MISRAC2004-20.3_c" enabled="true" />
                                <check name="MISRAC2004-20.3_d" enabled="true" />
                                <check name="MISRAC2004-20.3_e" enabled="true" />
                                <check name="MISRAC2004-20.3_f" enabled="true" />
                                <check name="MISRAC2004-20.3_g" enabled="true" />
                                <check name="MISRAC2004-20.3_h" enabled="true" />
                                <check name="MISRAC2004-20.3_i" enabled="true" />
                                <check name="MISRAC2004-20.4" enabled="true" />
                                <check name="MISRAC2004-20.5" enabled="true" />
                                <check name="MISRAC2004-20.6" enabled="true" />
                                <check name="MISRAC2004-20.7" enabled="true" />
                                <check name="MISRAC2004-20.8" enabled="true" />
                                <check name="MISRAC2004-20.9" enabled="true" />
                                <check name="MISRAC2004-20.10" enabled="true" />
                                <check name="MISRAC2004-20.11" enabled="true" />
                                <check name="MISRAC2004-20.12" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC2012" enabled="false">
                            <group enabled="true" name="MISRAC2012-Dir-4">
                                <check name="MISRAC2012-Dir-4.3" enabled="true" />
                                <check name="MISRAC2012-Dir-4.4" enabled="false" />
                                <check name="MISRAC2012-Dir-4.5" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.8" enabled="false" />
                                <check name="MISRAC2012-Dir-4.9" enabled="false" />
                                <check name="MISRAC2012-Dir-4.10" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_d" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_e" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_f" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_g" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_h" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_i" enabled="false" />
                                <check name="MISRAC2012-Dir-4.12" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_b" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_c" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_d" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_e" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_f" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_g" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_h" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-1">
                                <check name="MISRAC2012-Rule-1.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_c" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_d" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_e" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_f" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_g" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_h" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_i" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_j" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_k" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_m" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_n" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_o" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_p" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_q" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_r" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_s" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_t" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_u" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_v" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_w" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-2">
                                <check name="MISRAC2012-Rule-2.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-2.3" enabled="false" />
                                <check name="MISRAC2012-Rule-2.4" enabled="false" />
                                <check name="MISRAC2012-Rule-2.5" enabled="false" />
                                <check name="MISRAC2012-Rule-2.6" enabled="false" />
                                <check name="MISRAC2012-Rule-2.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-3">
                                <check name="MISRAC2012-Rule-3.1" enabled="true" />
                                <check name="MISRAC2012-Rule-3.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-5">
                                <check name="MISRAC2012-Rule-5.1" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.6" enabled="true" />
                                <check name="MISRAC2012-Rule-5.7" enabled="true" />
                                <check name="MISRAC2012-Rule-5.8" enabled="true" />
                                <check name="MISRAC2012-Rule-5.9" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-6">
                                <check name="MISRAC2012-Rule-6.1" enabled="true" />
                                <check name="MISRAC2012-Rule-6.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-7">
                                <check name="MISRAC2012-Rule-7.1" enabled="true" />
                                <check name="MISRAC2012-Rule-7.2" enabled="true" />
                                <check name="MISRAC2012-Rule-7.3" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-8">
                                <check name="MISRAC2012-Rule-8.1" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.4" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.7" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_a" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_b" enabled="false" />
                                <check name="MISRAC2012-Rule-8.10" enabled="true" />
                                <check name="MISRAC2012-Rule-8.11" enabled="false" />
                                <check name="MISRAC2012-Rule-8.12" enabled="true" />
                                <check name="MISRAC2012-Rule-8.13" enabled="false" />
                                <check name="MISRAC2012-Rule-8.14" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-9">
                                <check name="MISRAC2012-Rule-9.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_e" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_f" enabled="true" />
                                <check name="MISRAC2012-Rule-9.2" enabled="true" />
                                <check name="MISRAC2012-Rule-9.3" enabled="true" />
                                <check name="MISRAC2012-Rule-9.4" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-10">
                                <check name="MISRAC2012-Rule-10.1_R2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R4" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R5" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R8" enabled="true" />
                                <check name="MISRAC2012-Rule-10.2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-10.5" enabled="false" />
                                <check name="MISRAC2012-Rule-10.6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-11">
                                <check name="MISRAC2012-Rule-11.1" enabled="true" />
                                <check name="MISRAC2012-Rule-11.2" enabled="true" />
                                <check name="MISRAC2012-Rule-11.3" enabled="true" />
                                <check name="MISRAC2012-Rule-11.4" enabled="false" />
                                <check name="MISRAC2012-Rule-11.5" enabled="false" />
                                <check name="MISRAC2012-Rule-11.6" enabled="true" />
                                <check name="MISRAC2012-Rule-11.7" enabled="true" />
                                <check name="MISRAC2012-Rule-11.8" enabled="true" />
                                <check name="MISRAC2012-Rule-11.9" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-12">
                                <check name="MISRAC2012-Rule-12.1" enabled="false" />
                                <check name="MISRAC2012-Rule-12.2" enabled="true" />
                                <check name="MISRAC2012-Rule-12.3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-13">
                                <check name="MISRAC2012-Rule-13.1" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-13.3" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_a" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_b" enabled="false" />
                                <check name="MISRAC2012-Rule-13.5" enabled="true" />
                                <check name="MISRAC2012-Rule-13.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-14">
                                <check name="MISRAC2012-Rule-14.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.2" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_c" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-15">
                                <check name="MISRAC2012-Rule-15.1" enabled="false" />
                                <check name="MISRAC2012-Rule-15.2" enabled="true" />
                                <check name="MISRAC2012-Rule-15.3" enabled="true" />
                                <check name="MISRAC2012-Rule-15.4" enabled="false" />
                                <check name="MISRAC2012-Rule-15.5" enabled="false" />
                                <check name="MISRAC2012-Rule-15.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_e" enabled="true" />
                                <check name="MISRAC2012-Rule-15.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-16">
                                <check name="MISRAC2012-Rule-16.1" enabled="true" />
                                <check name="MISRAC2012-Rule-16.2" enabled="true" />
                                <check name="MISRAC2012-Rule-16.3" enabled="true" />
                                <check name="MISRAC2012-Rule-16.4" enabled="true" />
                                <check name="MISRAC2012-Rule-16.5" enabled="true" />
                                <check name="MISRAC2012-Rule-16.6" enabled="true" />
                                <check name="MISRAC2012-Rule-16.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-17">
                                <check name="MISRAC2012-Rule-17.1" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-17.3" enabled="true" />
                                <check name="MISRAC2012-Rule-17.4" enabled="true" />
                                <check name="MISRAC2012-Rule-17.5" enabled="false" />
                                <check name="MISRAC2012-Rule-17.6" enabled="true" />
                                <check name="MISRAC2012-Rule-17.7" enabled="true" />
                                <check name="MISRAC2012-Rule-17.8" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-18">
                                <check name="MISRAC2012-Rule-18.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.2" enabled="true" />
                                <check name="MISRAC2012-Rule-18.3" enabled="true" />
                                <check name="MISRAC2012-Rule-18.4" enabled="true" />
                                <check name="MISRAC2012-Rule-18.5" enabled="false" />
                                <check name="MISRAC2012-Rule-18.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.7" enabled="true" />
                                <check name="MISRAC2012-Rule-18.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-19">
                                <check name="MISRAC2012-Rule-19.1" enabled="true" />
                                <check name="MISRAC2012-Rule-19.2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-20">
                                <check name="MISRAC2012-Rule-20.1" enabled="false" />
                                <check name="MISRAC2012-Rule-20.2" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-20.5" enabled="false" />
                                <check name="MISRAC2012-Rule-20.7" enabled="true" />
                                <check name="MISRAC2012-Rule-20.10" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-21">
                                <check name="MISRAC2012-Rule-21.1" enabled="true" />
                                <check name="MISRAC2012-Rule-21.2" enabled="true" />
                                <check name="MISRAC2012-Rule-21.3" enabled="true" />
                                <check name="MISRAC2012-Rule-21.4" enabled="true" />
                                <check name="MISRAC2012-Rule-21.5" enabled="true" />
                                <check name="MISRAC2012-Rule-21.6" enabled="true" />
                                <check name="MISRAC2012-Rule-21.7" enabled="true" />
                                <check name="MISRAC2012-Rule-21.8" enabled="true" />
                                <check name="MISRAC2012-Rule-21.9" enabled="true" />
                                <check name="MISRAC2012-Rule-21.10" enabled="true" />
                                <check name="MISRAC2012-Rule-21.11" enabled="true" />
                                <check name="MISRAC2012-Rule-21.12_a" enabled="false" />
                                <check name="MISRAC2012-Rule-21.12_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-22">
                                <check name="MISRAC2012-Rule-22.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-22.3" enabled="true" />
                                <check name="MISRAC2012-Rule-22.4" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.6" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC++2008" enabled="false">
                            <group enabled="true" name="MISRAC++2008-0-1">
                                <check name="MISRAC++2008-0-1-1" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_c" enabled="true" />
                                <check name="MISRAC++2008-0-1-3" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-6" enabled="true" />
                                <check name="MISRAC++2008-0-1-7" enabled="true" />
                                <check name="MISRAC++2008-0-1-8" enabled="false" />
                                <check name="MISRAC++2008-0-1-9" enabled="true" />
                                <check name="MISRAC++2008-0-1-11" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-2">
                                <check name="MISRAC++2008-0-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-3">
                                <check name="MISRAC++2008-0-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-7">
                                <check name="MISRAC++2008-2-7-1" enabled="true" />
                                <check name="MISRAC++2008-2-7-2" enabled="true" />
                                <check name="MISRAC++2008-2-7-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-10">
                                <check name="MISRAC++2008-2-10-1" enabled="true" />
                                <check name="MISRAC++2008-2-10-2" enabled="true" />
                                <check name="MISRAC++2008-2-10-3" enabled="true" />
                                <check name="MISRAC++2008-2-10-4" enabled="true" />
                                <check name="MISRAC++2008-2-10-5" enabled="false" />
                                <check name="MISRAC++2008-2-10-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-13">
                                <check name="MISRAC++2008-2-13-2" enabled="true" />
                                <check name="MISRAC++2008-2-13-3" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_a" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-1">
                                <check name="MISRAC++2008-3-1-1" enabled="true" />
                                <check name="MISRAC++2008-3-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-9">
                                <check name="MISRAC++2008-3-9-2" enabled="false" />
                                <check name="MISRAC++2008-3-9-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-4-5">
                                <check name="MISRAC++2008-4-5-1" enabled="true" />
                                <check name="MISRAC++2008-4-5-2" enabled="true" />
                                <check name="MISRAC++2008-4-5-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-0">
                                <check name="MISRAC++2008-5-0-1_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-2" enabled="false" />
                                <check name="MISRAC++2008-5-0-3" enabled="true" />
                                <check name="MISRAC++2008-5-0-4" enabled="true" />
                                <check name="MISRAC++2008-5-0-5" enabled="true" />
                                <check name="MISRAC++2008-5-0-6" enabled="true" />
                                <check name="MISRAC++2008-5-0-7" enabled="true" />
                                <check name="MISRAC++2008-5-0-8" enabled="true" />
                                <check name="MISRAC++2008-5-0-9" enabled="true" />
                                <check name="MISRAC++2008-5-0-10" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-14" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_e" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_f" enabled="true" />
                                <check name="MISRAC++2008-5-0-19" enabled="true" />
                                <check name="MISRAC++2008-5-0-21" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-2">
                                <check name="MISRAC++2008-5-2-4" enabled="true" />
                                <check name="MISRAC++2008-5-2-5" enabled="true" />
                                <check name="MISRAC++2008-5-2-6" enabled="true" />
                                <check name="MISRAC++2008-5-2-7" enabled="true" />
                                <check name="MISRAC++2008-5-2-9" enabled="false" />
                                <check name="MISRAC++2008-5-2-10" enabled="false" />
                                <check name="MISRAC++2008-5-2-11_a" enabled="true" />
                                <check name="MISRAC++2008-5-2-11_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-3">
                                <check name="MISRAC++2008-5-3-1" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_a" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_b" enabled="true" />
                                <check name="MISRAC++2008-5-3-3" enabled="true" />
                                <check name="MISRAC++2008-5-3-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-8">
                                <check name="MISRAC++2008-5-8-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-14">
                                <check name="MISRAC++2008-5-14-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-18">
                                <check name="MISRAC++2008-5-18-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-19">
                                <check name="MISRAC++2008-5-19-1" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-2">
                                <check name="MISRAC++2008-6-2-1" enabled="true" />
                                <check name="MISRAC++2008-6-2-2" enabled="true" />
                                <check name="MISRAC++2008-6-2-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-3">
                                <check name="MISRAC++2008-6-3-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_b" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_c" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-4">
                                <check name="MISRAC++2008-6-4-1" enabled="true" />
                                <check name="MISRAC++2008-6-4-2" enabled="true" />
                                <check name="MISRAC++2008-6-4-3" enabled="true" />
                                <check name="MISRAC++2008-6-4-4" enabled="true" />
                                <check name="MISRAC++2008-6-4-5" enabled="true" />
                                <check name="MISRAC++2008-6-4-6" enabled="true" />
                                <check name="MISRAC++2008-6-4-7" enabled="true" />
                                <check name="MISRAC++2008-6-4-8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-5">
                                <check name="MISRAC++2008-6-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-5-2" enabled="true" />
                                <check name="MISRAC++2008-6-5-3" enabled="true" />
                                <check name="MISRAC++2008-6-5-4" enabled="true" />
                                <check name="MISRAC++2008-6-5-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-6">
                                <check name="MISRAC++2008-6-6-1" enabled="true" />
                                <check name="MISRAC++2008-6-6-2" enabled="true" />
                                <check name="MISRAC++2008-6-6-4" enabled="true" />
                                <check name="MISRAC++2008-6-6-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-1">
                                <check name="MISRAC++2008-7-1-1" enabled="true" />
                                <check name="MISRAC++2008-7-1-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-2">
                                <check name="MISRAC++2008-7-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-4">
                                <check name="MISRAC++2008-7-4-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-5">
                                <check name="MISRAC++2008-7-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_c" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_d" enabled="true" />
                                <check name="MISRAC++2008-7-5-4_a" enabled="false" />
                                <check name="MISRAC++2008-7-5-4_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-0">
                                <check name="MISRAC++2008-8-0-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-4">
                                <check name="MISRAC++2008-8-4-1" enabled="true" />
                                <check name="MISRAC++2008-8-4-3" enabled="true" />
                                <check name="MISRAC++2008-8-4-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-5">
                                <check name="MISRAC++2008-8-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_c" enabled="true" />
                                <check name="MISRAC++2008-8-5-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-3">
                                <check name="MISRAC++2008-9-3-1" enabled="true" />
                                <check name="MISRAC++2008-9-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-5">
                                <check name="MISRAC++2008-9-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-6">
                                <check name="MISRAC++2008-9-6-2" enabled="true" />
                                <check name="MISRAC++2008-9-6-3" enabled="true" />
                                <check name="MISRAC++2008-9-6-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-12-1">
                                <check name="MISRAC++2008-12-1-1_a" enabled="true" />
                                <check name="MISRAC++2008-12-1-1_b" enabled="true" />
                                <check name="MISRAC++2008-12-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-0">
                                <check name="MISRAC++2008-15-0-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-1">
                                <check name="MISRAC++2008-15-1-2" enabled="true" />
                                <check name="MISRAC++2008-15-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-3">
                                <check name="MISRAC++2008-15-3-1" enabled="true" />
                                <check name="MISRAC++2008-15-3-2" enabled="false" />
                                <check name="MISRAC++2008-15-3-3" enabled="true" />
                                <check name="MISRAC++2008-15-3-4" enabled="true" />
                                <check name="MISRAC++2008-15-3-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-5">
                                <check name="MISRAC++2008-15-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-0">
                                <check name="MISRAC++2008-16-0-3" enabled="true" />
                                <check name="MISRAC++2008-16-0-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-2">
                                <check name="MISRAC++2008-16-2-2" enabled="true" />
                                <check name="MISRAC++2008-16-2-3" enabled="true" />
                                <check name="MISRAC++2008-16-2-4" enabled="true" />
                                <check name="MISRAC++2008-16-2-5" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-3">
                                <check name="MISRAC++2008-16-3-1" enabled="true" />
                                <check name="MISRAC++2008-16-3-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-17-0">
                                <check name="MISRAC++2008-17-0-1" enabled="true" />
                                <check name="MISRAC++2008-17-0-3" enabled="true" />
                                <check name="MISRAC++2008-17-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-0">
                                <check name="MISRAC++2008-18-0-1" enabled="true" />
                                <check name="MISRAC++2008-18-0-2" enabled="true" />
                                <check name="MISRAC++2008-18-0-3" enabled="true" />
                                <check name="MISRAC++2008-18-0-4" enabled="true" />
                                <check name="MISRAC++2008-18-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-2">
                                <check name="MISRAC++2008-18-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-4">
                                <check name="MISRAC++2008-18-4-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-7">
                                <check name="MISRAC++2008-18-7-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-19-3">
                                <check name="MISRAC++2008-19-3-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-27-0">
                                <check name="MISRAC++2008-27-0-1" enabled="true" />
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group>
        <name>Application</name>
        <group>
            <name>EWARM</name>
            <file>
                <name>$PROJ_DIR$\startup_stm32h743xx.s</name>
            </file>
        </group>
        <group>
            <name>User</name>
            <group>
                <name>Core</name>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\adc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\dma.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\fdcan.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\freertos.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\gpio.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\i2c.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\iwdg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\main.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\mdma.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\rng.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\rtc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\sdmmc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\spi.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\stm32h7xx_hal_msp.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\stm32h7xx_hal_timebase_tim.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\stm32h7xx_it.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\tim.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\Core\Src\usart.c</name>
                </file>
            </group>
            <group>
                <name>FATFS</name>
                <group>
                    <name>App</name>
                    <file>
                        <name>$PROJ_DIR$\..\FATFS\App\fatfs.c</name>
                    </file>
                </group>
                <group>
                    <name>Target</name>
                    <file>
                        <name>$PROJ_DIR$\..\FATFS\Target\user_diskio.c</name>
                    </file>
                </group>
            </group>
            <group>
                <name>USB_DEVICE</name>
                <group>
                    <name>App</name>
                    <file>
                        <name>$PROJ_DIR$\..\USB_DEVICE\App\usb_device.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\USB_DEVICE\App\usbd_cdc_if.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\USB_DEVICE\App\usbd_desc.c</name>
                    </file>
                </group>
                <group>
                    <name>Target</name>
                    <file>
                        <name>$PROJ_DIR$\..\USB_DEVICE\Target\usbd_conf.c</name>
                    </file>
                </group>
            </group>
        </group>
    </group>
    <group>
        <name>Common</name>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\bsp_mmc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\buzzer.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\cmox_low_level.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\common.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\crc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\firmware.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\flash_if.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_adc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_AesEncrypt.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_base64.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\Git_BatteryRelayControl.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_bkSRAM.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_can.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_cli.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_CRC32.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_csac.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_eth.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_fsutil.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_function_list.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_global.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_hsm.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_hsm_api.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_HSM_Operations.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_HSM_SPICommand.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_i2c.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_ioctl.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_iwdg.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_kl.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_ListDiag.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_mcp2518fd.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_mmc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_mqtt_PubMsg.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_mqtt_Topic.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_OBDcomm.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_pm.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_pool.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_protocol.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_rs9116.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_rs9116_update.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_rtc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_sensor.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_sha1.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_test.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_vci.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\git_zip.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\led.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\00_Common\src\sw_timer.c</name>
        </file>
    </group>
    <group>
        <name>Drivers</name>
        <group>
            <name>CMSIS</name>
            <file>
                <name>$PROJ_DIR$\..\Core\Src\system_stm32h7xx.c</name>
            </file>
        </group>
        <group>
            <name>MCP2518FD</name>
            <file>
                <name>$PROJ_DIR$\..\..\11_Driver\mcp25xxfd_driver\canfdspi\drv_canfdspi_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\11_Driver\mcp25xxfd_driver\spi\drv_spi.c</name>
            </file>
        </group>
        <group>
            <name>STM32H7xx_HAL_Driver</name>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_adc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_adc_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_cortex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_crc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_crc_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_dma.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_dma_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_exti.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_fdcan.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_flash.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_flash_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_gpio.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_hsem.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_i2c.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_i2c_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_iwdg.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_mdma.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_mmc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_mmc_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_pcd.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_pcd_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_pwr.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_pwr_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_rcc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_rcc_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_rng.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_rtc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_rtc_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_spi.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_spi_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_tim.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_tim_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_uart.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_hal_uart_ex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_ll_sdmmc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Drivers\STM32H7xx_HAL_Driver\Src\stm32h7xx_ll_usb.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>Middlewares</name>
        <group>
            <name>CycloneTCP</name>
            <group>
                <name>common</name>
                <file>
                    <name>$PROJ_DIR$\..\..\11_CycloneTCP\common\cpu_endian.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\11_CycloneTCP\common\date_time.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\11_CycloneTCP\common\debug.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\11_CycloneTCP\common\os_port_freertos.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\11_CycloneTCP\common\path.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\11_CycloneTCP\common\resource_manager.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\11_CycloneTCP\common\str.c</name>
                </file>
            </group>
            <group>
                <name>cyclone_tcp</name>
                <group>
                    <name>core</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\bsd_socket.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\ethernet.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\ethernet_misc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\ip.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\net.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\net_mem.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\net_misc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\nic.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\ping.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\raw_socket.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\socket.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\tcp.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\tcp_fsm.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\tcp_misc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\tcp_timer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\core\udp.c</name>
                    </file>
                </group>
                <group>
                    <name>dhcp</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\dhcp\dhcp_client.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\dhcp\dhcp_common.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\dhcp\dhcp_debug.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\dhcp\dhcp_server.c</name>
                    </file>
                </group>
                <group>
                    <name>dns</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\dns\dns_cache.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\dns\dns_client.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\dns\dns_common.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\dns\dns_debug.c</name>
                    </file>
                </group>
                <group>
                    <name>drivers</name>
                    <group>
                        <name>mac</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\drivers\mac\stm32h7xx_eth_driver.c</name>
                        </file>
                    </group>
                    <group>
                        <name>switch</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\drivers\switch\lan937x_driver.c</name>
                        </file>
                    </group>
                </group>
                <group>
                    <name>http</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\http_client.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\http_client_auth.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\http_client_misc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\http_client_transport.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\http_common.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\http_server.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\http_server_auth.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\http_server_misc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\mime.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\http\ssi.c</name>
                    </file>
                </group>
                <group>
                    <name>ipv4</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv4\arp.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv4\auto_ip.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv4\icmp.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv4\igmp.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv4\ipv4.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv4\ipv4_frag.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv4\ipv4_misc.c</name>
                    </file>
                </group>
                <group>
                    <name>ipv6</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\icmpv6.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ipv6.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ipv6_frag.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ipv6_misc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ipv6_pmtu.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ipv6_routing.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\mld.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ndp.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ndp_cache.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ndp_misc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\ndp_router_adv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\ipv6\slaac.c</name>
                    </file>
                </group>
                <group>
                    <name>limnr</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\llmnr\llmnr_client.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\llmnr\llmnr_common.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\llmnr\llmnr_responder.c</name>
                    </file>
                </group>
                <group>
                    <name>mdns</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\mdns\mdns_client.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\mdns\mdns_common.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\mdns\mdns_responder.c</name>
                    </file>
                </group>
                <group>
                    <name>netbios</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\netbios\nbns_client.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\netbios\nbns_common.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\11_CycloneTCP\cyclone_tcp\netbios\nbns_responder.c</name>
                    </file>
                </group>
            </group>
        </group>
        <group>
            <name>FatFs</name>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\option\ccsbcs.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\diskio.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\ff.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\ff_gen_drv.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FatFs\src\option\syscall.c</name>
            </file>
        </group>
        <group>
            <name>FreeRTOS</name>
            <group>
                <name>RS9116</name>
                <group>
                    <name>SDK_2.10.0.6</name>
                    <group>
                        <name>hal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_com_port.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_interrupt.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_ioports.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_platform_init.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_random.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_sdio.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_spi.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_mcu_uart.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\rsi_hal_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\hal\sl_hal_mcu_logging.c</name>
                        </file>
                    </group>
                    <group>
                        <name>sapi</name>
                        <group>
                            <name>bluetooth</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\bluetooth\rsi_ble_gap_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\bluetooth\rsi_ble_gatt_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\bluetooth\rsi_bt_a2dp_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\bluetooth\rsi_bt_avrcp_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\bluetooth\rsi_bt_common_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\bluetooth\rsi_bt_gap_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\bluetooth\rsi_bt_sbc_codec.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\bluetooth\rsi_bt_spp_apis.c</name>
                            </file>
                        </group>
                        <group>
                            <name>common</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\common\rsi_apis_non_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\common\rsi_apis_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\common\rsi_common_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\common\rsi_device_init_apis.c</name>
                            </file>
                        </group>
                        <group>
                            <name>crypto</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\crypto\rsi_crypto.c</name>
                            </file>
                        </group>
                        <group>
                            <name>driver</name>
                            <group>
                                <name>device_interface</name>
                                <group>
                                    <name>sdio</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\sdio\rsi_sdio_frame_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\sdio\rsi_sdio_iface_init.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\sdio\rsi_sdio_mem_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\sdio\rsi_sdio_reg_rd_wr.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>spi</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\spi\rsi_spi_frame_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\spi\rsi_spi_functs.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\spi\rsi_spi_iface_init.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\spi\rsi_spi_mem_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\spi\rsi_spi_reg_rd_wr.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>uart</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\device_interface\uart\rsi_uart.c</name>
                                    </file>
                                </group>
                            </group>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_bt_ble.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_common.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_device_init.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_driver.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_driver_event_handlers.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_events.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_events_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_iap.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_nwk.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_nwk_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_os_none.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_pkt_mgmt.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_pkt_mgmt_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_queue.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_queue_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_scheduler.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_scheduler_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_setregion_countryinfo.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_timer.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_utils.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_utils_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\driver\rsi_wlan.c</name>
                            </file>
                        </group>
                        <group>
                            <name>logging</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\logging\sl_app_logging.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\logging\sl_fw_logging.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\logging\sleep_wakeup_logging.c</name>
                            </file>
                        </group>
                        <group>
                            <name>network</name>
                            <group>
                                <name>protocols</name>
                                <group>
                                    <name>http_server</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\http_server\rsi_http_server.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\http_server\rsi_json_handlers.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>mdnsd_records</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\mdnsd_records\rsi_mdnsd_records.c</name>
                                    </file>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_dhcp_user_class.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_dns.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_emb_mqtt_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_firmware_upgradation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_ftp.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_http_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_http_ota_fw_up.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_mdnsd.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_mqtt_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_multicast.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_ota_fw_up.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_pop3_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_raw_data.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_smtp_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_sntp_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols\rsi_web_socket.c</name>
                                </file>
                            </group>
                            <group>
                                <name>socket</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\socket\rsi_socket.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\network\socket\rsi_socket_rom.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>rtos</name>
                            <group>
                                <name>freertos_wrapper</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\rtos\freertos_wrapper\rsi_os_wrapper.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>wlan</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\sapi\wlan\rsi_wlan_apis.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>third_party</name>
                        <group>
                            <name>mqtt_client</name>
                            <group>
                                <name>src</name>
                                <group>
                                    <name>MQTTPacket</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTPacket\src\MQTTConnectClient.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTPacket\src\MQTTDeserializePublish.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTPacket\src\MQTTFormat.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTPacket\src\MQTTPacket.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTPacket\src\MQTTSerializePublish.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTPacket\src\MQTTSubscribeClient.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTPacket\src\MQTTUnsubscribeClient.c</name>
                                    </file>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTT_sapi_wrappers.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTClient.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>sbc_audio_codec</name>
                        </group>
                    </group>
                </group>
                <group>
                    <name>SDK_2.11.1.3</name>
                    <group>
                        <name>hal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_com_port.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_interrupt.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_ioports.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_platform_init.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_random.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_sdio.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_spi.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_mcu_uart.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\rsi_hal_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\hal\sl_hal_mcu_logging.c</name>
                        </file>
                    </group>
                    <group>
                        <name>resources</name>
                        <group>
                            <name>certificates</name>
                        </group>
                    </group>
                    <group>
                        <name>sapi</name>
                        <group>
                            <name>bluetooth</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\bluetooth\rsi_ble_gap_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\bluetooth\rsi_ble_gatt_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\bluetooth\rsi_bt_a2dp_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\bluetooth\rsi_bt_avrcp_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\bluetooth\rsi_bt_common_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\bluetooth\rsi_bt_gap_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\bluetooth\rsi_bt_sbc_codec.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\bluetooth\rsi_bt_spp_apis.c</name>
                            </file>
                        </group>
                        <group>
                            <name>common</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\common\rsi_apis_non_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\common\rsi_apis_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\common\rsi_common_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\common\rsi_device_init_apis.c</name>
                            </file>
                        </group>
                        <group>
                            <name>crypto</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\crypto\rsi_crypto.c</name>
                            </file>
                        </group>
                        <group>
                            <name>driver</name>
                            <group>
                                <name>device_interface</name>
                                <group>
                                    <name>sdio</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\sdio\rsi_sdio_frame_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\sdio\rsi_sdio_iface_init.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\sdio\rsi_sdio_mem_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\sdio\rsi_sdio_reg_rd_wr.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>spi</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\spi\rsi_spi_frame_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\spi\rsi_spi_functs.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\spi\rsi_spi_iface_init.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\spi\rsi_spi_mem_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\spi\rsi_spi_reg_rd_wr.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>uart</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\device_interface\uart\rsi_uart.c</name>
                                    </file>
                                </group>
                            </group>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_bt_ble.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_common.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_device_init.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_driver.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_driver_event_handlers.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_events.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_events_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_iap.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_nwk.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_nwk_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_os_none.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_pkt_mgmt.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_pkt_mgmt_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_queue.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_queue_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_scheduler.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_scheduler_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_setregion_countryinfo.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_timer.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_utils.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_utils_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\driver\rsi_wlan.c</name>
                            </file>
                        </group>
                        <group>
                            <name>logging</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\logging\sl_app_logging.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\logging\sl_fw_logging.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\logging\sleep_wakeup_logging.c</name>
                            </file>
                        </group>
                        <group>
                            <name>network</name>
                            <group>
                                <name>protocols</name>
                                <group>
                                    <name>http_server</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\http_server\rsi_http_server.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\http_server\rsi_json_handlers.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>mdnsd_records</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\mdnsd_records\rsi_mdnsd_records.c</name>
                                    </file>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_dhcp_user_class.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_dns.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_emb_mqtt_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_firmware_upgradation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_ftp.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_http_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_http_ota_fw_up.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_mdnsd.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_mqtt_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_multicast.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_ota_fw_up.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_pop3_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_raw_data.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_smtp_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_sntp_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\protocols\rsi_web_socket.c</name>
                                </file>
                            </group>
                            <group>
                                <name>socket</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\socket\rsi_socket.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\network\socket\rsi_socket_rom.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>rtos</name>
                            <group>
                                <name>freertos_wrapper</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\rtos\freertos_wrapper\rsi_os_wrapper.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>wlan</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\sapi\wlan\rsi_wlan_apis.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>third_party</name>
                        <group>
                            <name>mqtt_client</name>
                            <group>
                                <name>sbc_audio_codec</name>
                                <group>
                                    <name>src</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\sbc_audio_codec\src\sbc_analysis.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\sbc_audio_codec\src\sbc_dct.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\sbc_audio_codec\src\sbc_dct_coeffs.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\sbc_audio_codec\src\sbc_enc_bit_alloc_mono.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\sbc_audio_codec\src\sbc_enc_bit_alloc_ste.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\sbc_audio_codec\src\sbc_enc_coeffs.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\sbc_audio_codec\src\sbc_encoder.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\sbc_audio_codec\src\sbc_packing.c</name>
                                    </file>
                                </group>
                            </group>
                            <group>
                                <name>src</name>
                                <group>
                                    <name>MQTTPacket</name>
                                    <group>
                                        <name>src</name>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTTPacket\src\MQTTConnectClient.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTTPacket\src\MQTTDeserializePublish.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTTPacket\src\MQTTFormat.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTTPacket\src\MQTTPacket.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTTPacket\src\MQTTSerializePublish.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTTPacket\src\MQTTSubscribeClient.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTTPacket\src\MQTTUnsubscribeClient.c</name>
                                        </file>
                                    </group>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTT_sapi_wrappers.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.11.1.3\third_party\mqtt_client\src\MQTTClient.c</name>
                                </file>
                            </group>
                        </group>
                    </group>
                </group>
                <group>
                    <name>SDK_2.8.0.0.45</name>
                    <group>
                        <name>hal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_com_port.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_interrupt.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_ioports.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_platform_init.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_random.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_sdio.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_spi.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_mcu_uart.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\rsi_hal_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\hal\sl_hal_mcu_logging.c</name>
                        </file>
                    </group>
                    <group>
                        <name>sapi</name>
                        <group>
                            <name>bluetooth</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\bluetooth\rsi_ble_gap_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\bluetooth\rsi_ble_gatt_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\bluetooth\rsi_bt_a2dp_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\bluetooth\rsi_bt_avrcp_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\bluetooth\rsi_bt_common_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\bluetooth\rsi_bt_gap_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\bluetooth\rsi_bt_sbc_codec.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\bluetooth\rsi_bt_spp_apis.c</name>
                            </file>
                        </group>
                        <group>
                            <name>common</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\common\rsi_apis_non_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\common\rsi_apis_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\common\rsi_common_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\common\rsi_device_init_apis.c</name>
                            </file>
                        </group>
                        <group>
                            <name>crypto</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\crypto\rsi_crypto.c</name>
                            </file>
                        </group>
                        <group>
                            <name>driver</name>
                            <group>
                                <name>driver_interface</name>
                                <group>
                                    <name>sdio</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\sdio\rsi_sdio_frame_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\sdio\rsi_sdio_iface_init.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\sdio\rsi_sdio_mem_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\sdio\rsi_sdio_reg_rd_wr.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>spi</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\spi\rsi_spi_frame_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\spi\rsi_spi_functs.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\spi\rsi_spi_iface_init.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\spi\rsi_spi_mem_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\spi\rsi_spi_reg_rd_wr.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>uart</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\device_interface\uart\rsi_uart.c</name>
                                    </file>
                                </group>
                            </group>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_bt_ble.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_common.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_device_init.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_driver.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_driver_event_handlers.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_events.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_events_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_iap.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_nwk.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_nwk_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_os_none.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_pkt_mgmt.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_pkt_mgmt_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_queue.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_queue_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_scheduler.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_scheduler_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_setregion_countryinfo.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_timer.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_utils.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_utils_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\driver\rsi_wlan.c</name>
                            </file>
                        </group>
                        <group>
                            <name>logging</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\logging\sl_app_logging.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\logging\sl_fw_logging.c</name>
                            </file>
                        </group>
                        <group>
                            <name>network</name>
                            <group>
                                <name>protocols</name>
                                <group>
                                    <name>http_server</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\http_server\rsi_http_server.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\http_server\rsi_json_handlers.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>mdnsd_records</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\mdnsd_records\rsi_mdnsd_records.c</name>
                                    </file>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_dhcp_user_class.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_dns.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_emb_mqtt_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_firmware_upgradation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_ftp.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_http_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_http_ota_fw_up.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_mdnsd.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_mqtt_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_multicast.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_ota_fw_up.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_pop3_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_raw_data.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_smtp_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_sntp_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\protocols\rsi_web_socket.c</name>
                                </file>
                            </group>
                            <group>
                                <name>socket</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\socket\rsi_socket.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\network\socket\rsi_socket_rom.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>rtos</name>
                            <group>
                                <name>freertos_wrapper</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\rtos\freertos_wrapper\port.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\rtos\freertos_wrapper\rsi_os_wrapper.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>wlan</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\sapi\wlan\rsi_wlan_apis.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>third_party</name>
                        <group>
                            <name>mqtt_client</name>
                            <group>
                                <name>src</name>
                                <group>
                                    <name>MQTTPacket</name>
                                    <group>
                                        <name>src</name>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTTPacket\src\MQTTConnectClient.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTTPacket\src\MQTTDeserializePublish.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTTPacket\src\MQTTFormat.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTTPacket\src\MQTTPacket.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTTPacket\src\MQTTSerializePublish.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTTPacket\src\MQTTSubscribeClient.c</name>
                                        </file>
                                        <file>
                                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTTPacket\src\MQTTUnsubscribeClient.c</name>
                                        </file>
                                    </group>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTT_sapi_wrappers.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\mqtt_client\src\MQTTClient.c</name>
                                    </file>
                                </group>
                            </group>
                        </group>
                        <group>
                            <name>sbc_audio_codec</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\sbc_audio_codec\src\sbc_analysis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\sbc_audio_codec\src\sbc_dct.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\sbc_audio_codec\src\sbc_dct_coeffs.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\sbc_audio_codec\src\sbc_enc_bit_alloc_mono.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\sbc_audio_codec\src\sbc_enc_bit_alloc_ste.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\sbc_audio_codec\src\sbc_enc_coeffs.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\sbc_audio_codec\src\sbc_encoder.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.8.0.0.45\third_party\sbc_audio_codec\src\sbc_packing.c</name>
                            </file>
                        </group>
                    </group>
                </group>
                <group>
                    <name>SDK_2.9.1.17</name>
                    <group>
                        <name>hal</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_com_port.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_interrupt.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_ioports.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_platform_init.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_random.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_sdio.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_spi.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_mcu_uart.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\rsi_hal_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\hal\sl_hal_mcu_logging.c</name>
                        </file>
                    </group>
                    <group>
                        <name>sapi</name>
                        <group>
                            <name>bluetooth</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\bluetooth\rsi_ble_gap_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\bluetooth\rsi_ble_gatt_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\bluetooth\rsi_bt_a2dp_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\bluetooth\rsi_bt_avrcp_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\bluetooth\rsi_bt_common_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\bluetooth\rsi_bt_gap_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\bluetooth\rsi_bt_sbc_codec.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\bluetooth\rsi_bt_spp_apis.c</name>
                            </file>
                        </group>
                        <group>
                            <name>common</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\common\rsi_apis_non_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\common\rsi_apis_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\common\rsi_common_apis.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\common\rsi_device_init_apis.c</name>
                            </file>
                        </group>
                        <group>
                            <name>crypto</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\crypto\rsi_crypto.c</name>
                            </file>
                        </group>
                        <group>
                            <name>driver</name>
                            <group>
                                <name>device_interface</name>
                                <group>
                                    <name>sdio</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\sdio\rsi_sdio_frame_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\sdio\rsi_sdio_iface_init.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\sdio\rsi_sdio_mem_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\sdio\rsi_sdio_reg_rd_wr.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>spi</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\spi\rsi_spi_frame_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\spi\rsi_spi_functs.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\spi\rsi_spi_iface_init.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\spi\rsi_spi_mem_rd_wr.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\spi\rsi_spi_reg_rd_wr.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>uart</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\device_interface\uart\rsi_uart.c</name>
                                    </file>
                                </group>
                            </group>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_bt_ble.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_common.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_device_init.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_driver.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_driver_event_handlers.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_events.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_events_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_iap.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_nwk.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_nwk_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_os_none.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_pkt_mgmt.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_pkt_mgmt_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_queue.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_queue_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_scheduler.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_scheduler_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_setregion_countryinfo.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_timer.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_utils.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_utils_rom.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\driver\rsi_wlan.c</name>
                            </file>
                        </group>
                        <group>
                            <name>logging</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\logging\sl_app_logging.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\logging\sl_fw_logging.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\logging\sleep_wakeup_logging.c</name>
                            </file>
                        </group>
                        <group>
                            <name>network</name>
                            <group>
                                <name>protocols</name>
                                <group>
                                    <name>http_server</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\http_server\rsi_http_server.c</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\http_server\rsi_json_handlers.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>mdnsd_records</name>
                                    <file>
                                        <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\mdnsd_records\rsi_mdnsd_records.c</name>
                                    </file>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_dhcp_user_class.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_dns.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_emb_mqtt_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_firmware_upgradation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_ftp.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_http_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_http_ota_fw_up.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_mdnsd.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_mqtt_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_multicast.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_ota_fw_up.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_pop3_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_raw_data.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_smtp_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_sntp_client.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\protocols\rsi_web_socket.c</name>
                                </file>
                            </group>
                            <group>
                                <name>socket</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\socket\rsi_socket.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\network\socket\rsi_socket_rom.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>rtos</name>
                            <group>
                                <name>freertos_wrapper</name>
                                <file>
                                    <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\rtos\freertos_wrapper\rsi_os_wrapper.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>wlan</name>
                            <file>
                                <name>$PROJ_DIR$\..\..\10_RS9116\SDK_2.9.1.17\sapi\wlan\rsi_wlan_apis.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>third_party</name>
                        <group>
                            <name>mqtt_client</name>
                            <group>
                                <name>src</name>
                                <group>
                                    <name>MQTTPacket</name>
                                </group>
                            </group>
                        </group>
                        <group>
                            <name>sbc_audio_codec</name>
                        </group>
                    </group>
                </group>
            </group>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS\cmsis_os.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\croutine.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\event_groups.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang\heap_4.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang\heap_5.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\list.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\port.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\portasm.s</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\queue.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\stream_buffer.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\tasks.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\timers.c</name>
            </file>
        </group>
        <group>
            <name>USB_Device_Library</name>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src\usbd_cdc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_core.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_ctlreq.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_ioreq.c</name>
            </file>
        </group>
        <group>
            <name>zlib</name>
            <group>
                <name>sys</name>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\adler32.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\compress.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\crc32.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\deflate.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\gzclose.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\gzlib.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\gzread.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\gzwrite.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\infback.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\inffast.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\inflate.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\inftrees.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\trees.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\uncompr.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\13_zlib\zutil.c</name>
            </file>
        </group>
    </group>
</project>
