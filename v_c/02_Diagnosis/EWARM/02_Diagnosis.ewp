# IAR project 02_Diagnosis.ewp, settings and files
configuration 02_Diagnosis (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743II ST STM32H743II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx; RSI_SPI_INTERFACE; RSI_BT_ENABLE; GIT_STM32H743; RSI_WITH_OS; RSI_WLAN_ENABLE; GIT_DEBUG; VCI_III_ASING_MODE=0; VCI_III_USB_HS; AddToTimer3; ADDTOLATCH_WIFI; NEW_VCI_III; LAN_9514; BD_ADDR_IN_ASCII; USE_INTERNAL_CAN_ONLY; NEWBOARD; LISTDIAG; VCI3_DIAG; ASYNC_MQTT; LARGE_DATA_SYNC; CANFD_PROTOCOL; CV_AUTOVIN; VCI3_NEW_HSM
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../FATFS/Target; ../FATFS/App; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ..\..\00_Common\inc; ..\..\11_CycloneTCP\common; ..\..\11_CycloneTCP\cyclone_tcp; ..\..\11_Driver\mcp25xxfd_driver\canfdspi; ..\..\11_Driver\mcp25xxfd_driver\spi; ..\..\10_RS9116\SDK_2.10.0.6\sapi\rtos\freertos_wrapper\inc; ..\..\10_RS9116\SDK_2.10.0.6\sapi\include; ..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src\MQTTPacket\src; ..\..\10_RS9116\SDK_2.10.0.6\third_party\mqtt_client\src; ..\..\10_RS9116\SDK_2.10.0.6\sapi\network\protocols; ..\..\00_Common\STM32CubeExpansion_Crypto_V4.0.1\Middlewares\ST\STM32_Cryptographic\include; ..\..\00_Common\STM32Cryptographic\inc; ..\..\00_Common\STM32Cryptographic\inc\Common; ..\Drivers\CMSIS\DSP\inc; ..\..\13_zlib; ..\..\10_RS9116\SDK_2.10.0.6\resources\certificates
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: C_vci3_main.bin
  ILINK.IlinkOutputFile: vci3_main.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\00_Common\STM32Cryptographic\Lib\STM32CryptographicV3.1.1_STM32H7_IARv8.a; ..\..\00_Common\STM32CubeExpansion_Crypto_V4.0.1\Middlewares\ST\STM32_Cryptographic\lib\libSTM32Cryptographic_CM7.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: adc.c dma.c fdcan.c freertos.c gpio.c i2c.c iwdg.c main.c mdma.c rng.c rtc.c sdmmc.c spi.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c tim.c usart.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Common
    ../../00_Common/src/: bsp_mmc.c buzzer.c cmox_low_level.c common.c crc.c firmware.c flash_if.c git_adc.c git_AesEncrypt.c git_base64.c Git_BatteryRelayControl.c git_bkSRAM.c git_can.c git_cli.c git_CRC32.c git_csac.c git_eth.c git_fsutil.c git_function_list.c git_global.c git_hsm.c git_hsm_api.c git_HSM_Operations.c git_HSM_SPICommand.c git_i2c.c git_ioctl.c git_iwdg.c git_kl.c git_ListDiag.c git_mcp2518fd.c git_mmc.c git_mqtt_PubMsg.c git_mqtt_Topic.c git_OBDcomm.c git_pm.c git_pool.c git_protocol.c git_rs9116.c git_rs9116_update.c git_rtc.c git_sensor.c git_sha1.c git_test.c git_vci.c git_zip.c led.c sw_timer.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/MCP2518FD
    ../../11_Driver/mcp25xxfd_driver/canfdspi/: drv_canfdspi_api.c
    ../../11_Driver/mcp25xxfd_driver/spi/: drv_spi.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Middlewares/CycloneTCP/common
    ../../11_CycloneTCP/common/: cpu_endian.c date_time.c debug.c os_port_freertos.c path.c resource_manager.c str.c
  group Middlewares/CycloneTCP/cyclone_tcp/core
    ../../11_CycloneTCP/cyclone_tcp/core/: bsd_socket.c ethernet.c ethernet_misc.c ip.c net.c net_mem.c net_misc.c nic.c ping.c raw_socket.c socket.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
  group Middlewares/CycloneTCP/cyclone_tcp/dhcp
    ../../11_CycloneTCP/cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c dhcp_server.c
  group Middlewares/CycloneTCP/cyclone_tcp/dns
    ../../11_CycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
  group Middlewares/CycloneTCP/cyclone_tcp/drivers/mac
    ../../11_CycloneTCP/cyclone_tcp/drivers/mac/: stm32h7xx_eth_driver.c
  group Middlewares/CycloneTCP/cyclone_tcp/drivers/switch
    ../../11_CycloneTCP/cyclone_tcp/drivers/switch/: lan937x_driver.c
  group Middlewares/CycloneTCP/cyclone_tcp/http
    ../../11_CycloneTCP/cyclone_tcp/http/: http_client.c http_client_auth.c http_client_misc.c http_client_transport.c http_common.c http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group Middlewares/CycloneTCP/cyclone_tcp/ipv4
    ../../11_CycloneTCP/cyclone_tcp/ipv4/: arp.c auto_ip.c icmp.c igmp.c ipv4.c ipv4_frag.c ipv4_misc.c
  group Middlewares/CycloneTCP/cyclone_tcp/ipv6
    ../../11_CycloneTCP/cyclone_tcp/ipv6/: icmpv6.c ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c ipv6_routing.c mld.c ndp.c ndp_cache.c ndp_misc.c ndp_router_adv.c slaac.c
  group Middlewares/CycloneTCP/cyclone_tcp/limnr
    ../../11_CycloneTCP/cyclone_tcp/llmnr/: llmnr_client.c llmnr_common.c llmnr_responder.c
  group Middlewares/CycloneTCP/cyclone_tcp/mdns
    ../../11_CycloneTCP/cyclone_tcp/mdns/: mdns_client.c mdns_common.c mdns_responder.c
  group Middlewares/CycloneTCP/cyclone_tcp/netbios
    ../../11_CycloneTCP/cyclone_tcp/netbios/: nbns_client.c nbns_common.c nbns_responder.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_5.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/hal
    ../../10_RS9116/SDK_2.10.0.6/hal/: rsi_hal_mcu_com_port.c rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_hal_timer.c sl_hal_mcu_logging.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/bluetooth
    ../../10_RS9116/SDK_2.10.0.6/sapi/bluetooth/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_a2dp_apis.c rsi_bt_avrcp_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_sbc_codec.c rsi_bt_spp_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/common
    ../../10_RS9116/SDK_2.10.0.6/sapi/common/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_common_apis.c rsi_device_init_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/crypto
    ../../10_RS9116/SDK_2.10.0.6/sapi/crypto/: rsi_crypto.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/driver
    ../../10_RS9116/SDK_2.10.0.6/sapi/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_events_rom.c rsi_iap.c rsi_nwk.c rsi_nwk_rom.c rsi_os_none.c rsi_pkt_mgmt.c rsi_pkt_mgmt_rom.c rsi_queue.c rsi_queue_rom.c rsi_scheduler.c rsi_scheduler_rom.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_utils_rom.c rsi_wlan.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/driver/device_interface/sdio
    ../../10_RS9116/SDK_2.10.0.6/sapi/driver/device_interface/sdio/: rsi_sdio_frame_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_mem_rd_wr.c rsi_sdio_reg_rd_wr.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/driver/device_interface/spi
    ../../10_RS9116/SDK_2.10.0.6/sapi/driver/device_interface/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/driver/device_interface/uart
    ../../10_RS9116/SDK_2.10.0.6/sapi/driver/device_interface/uart/: rsi_uart.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/logging
    ../../10_RS9116/SDK_2.10.0.6/sapi/logging/: sl_app_logging.c sl_fw_logging.c sleep_wakeup_logging.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/network/protocols
    ../../10_RS9116/SDK_2.10.0.6/sapi/network/protocols/: rsi_dhcp_user_class.c rsi_dns.c rsi_emb_mqtt_client.c rsi_firmware_upgradation.c rsi_ftp.c rsi_http_client.c rsi_http_ota_fw_up.c rsi_mdnsd.c rsi_mqtt_client.c rsi_multicast.c rsi_ota_fw_up.c rsi_pop3_client.c rsi_raw_data.c rsi_smtp_client.c rsi_sntp_client.c rsi_web_socket.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/network/protocols/http_server
    ../../10_RS9116/SDK_2.10.0.6/sapi/network/protocols/http_server/: rsi_http_server.c rsi_json_handlers.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/network/protocols/mdnsd_records
    ../../10_RS9116/SDK_2.10.0.6/sapi/network/protocols/mdnsd_records/: rsi_mdnsd_records.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/network/socket
    ../../10_RS9116/SDK_2.10.0.6/sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/rtos/freertos_wrapper
    ../../10_RS9116/SDK_2.10.0.6/sapi/rtos/freertos_wrapper/: rsi_os_wrapper.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/sapi/wlan
    ../../10_RS9116/SDK_2.10.0.6/sapi/wlan/: rsi_wlan_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/third_party/mqtt_client/src
    ../../10_RS9116/SDK_2.10.0.6/third_party/mqtt_client/src/: MQTT_sapi_wrappers.c MQTTClient.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.10.0.6/third_party/mqtt_client/src/MQTTPacket
    ../../10_RS9116/SDK_2.10.0.6/third_party/mqtt_client/src/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/hal
    ../../10_RS9116/SDK_2.11.1.3/hal/: rsi_hal_mcu_com_port.c rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_hal_timer.c sl_hal_mcu_logging.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/bluetooth
    ../../10_RS9116/SDK_2.11.1.3/sapi/bluetooth/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_a2dp_apis.c rsi_bt_avrcp_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_sbc_codec.c rsi_bt_spp_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/common
    ../../10_RS9116/SDK_2.11.1.3/sapi/common/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_common_apis.c rsi_device_init_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/crypto
    ../../10_RS9116/SDK_2.11.1.3/sapi/crypto/: rsi_crypto.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/driver
    ../../10_RS9116/SDK_2.11.1.3/sapi/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_events_rom.c rsi_iap.c rsi_nwk.c rsi_nwk_rom.c rsi_os_none.c rsi_pkt_mgmt.c rsi_pkt_mgmt_rom.c rsi_queue.c rsi_queue_rom.c rsi_scheduler.c rsi_scheduler_rom.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_utils_rom.c rsi_wlan.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/driver/device_interface/sdio
    ../../10_RS9116/SDK_2.11.1.3/sapi/driver/device_interface/sdio/: rsi_sdio_frame_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_mem_rd_wr.c rsi_sdio_reg_rd_wr.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/driver/device_interface/spi
    ../../10_RS9116/SDK_2.11.1.3/sapi/driver/device_interface/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/driver/device_interface/uart
    ../../10_RS9116/SDK_2.11.1.3/sapi/driver/device_interface/uart/: rsi_uart.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/logging
    ../../10_RS9116/SDK_2.11.1.3/sapi/logging/: sl_app_logging.c sl_fw_logging.c sleep_wakeup_logging.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/network/protocols
    ../../10_RS9116/SDK_2.11.1.3/sapi/network/protocols/: rsi_dhcp_user_class.c rsi_dns.c rsi_emb_mqtt_client.c rsi_firmware_upgradation.c rsi_ftp.c rsi_http_client.c rsi_http_ota_fw_up.c rsi_mdnsd.c rsi_mqtt_client.c rsi_multicast.c rsi_ota_fw_up.c rsi_pop3_client.c rsi_raw_data.c rsi_smtp_client.c rsi_sntp_client.c rsi_web_socket.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/network/protocols/http_server
    ../../10_RS9116/SDK_2.11.1.3/sapi/network/protocols/http_server/: rsi_http_server.c rsi_json_handlers.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/network/protocols/mdnsd_records
    ../../10_RS9116/SDK_2.11.1.3/sapi/network/protocols/mdnsd_records/: rsi_mdnsd_records.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/network/socket
    ../../10_RS9116/SDK_2.11.1.3/sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/rtos/freertos_wrapper
    ../../10_RS9116/SDK_2.11.1.3/sapi/rtos/freertos_wrapper/: rsi_os_wrapper.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/sapi/wlan
    ../../10_RS9116/SDK_2.11.1.3/sapi/wlan/: rsi_wlan_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/third_party/mqtt_client/sbc_audio_codec/src
    ../../10_RS9116/SDK_2.11.1.3/third_party/sbc_audio_codec/src/: sbc_analysis.c sbc_dct.c sbc_dct_coeffs.c sbc_enc_bit_alloc_mono.c sbc_enc_bit_alloc_ste.c sbc_enc_coeffs.c sbc_encoder.c sbc_packing.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/third_party/mqtt_client/src
    ../../10_RS9116/SDK_2.11.1.3/third_party/mqtt_client/src/: MQTT_sapi_wrappers.c MQTTClient.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.11.1.3/third_party/mqtt_client/src/MQTTPacket/src
    ../../10_RS9116/SDK_2.11.1.3/third_party/mqtt_client/src/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/hal
    ../../10_RS9116/SDK_2.8.0.0.45/hal/: rsi_hal_mcu_com_port.c rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_hal_timer.c sl_hal_mcu_logging.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/bluetooth
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/bluetooth/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_a2dp_apis.c rsi_bt_avrcp_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_sbc_codec.c rsi_bt_spp_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/common
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/common/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_common_apis.c rsi_device_init_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/crypto
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/crypto/: rsi_crypto.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/driver
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_events_rom.c rsi_iap.c rsi_nwk.c rsi_nwk_rom.c rsi_os_none.c rsi_pkt_mgmt.c rsi_pkt_mgmt_rom.c rsi_queue.c rsi_queue_rom.c rsi_scheduler.c rsi_scheduler_rom.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_utils_rom.c rsi_wlan.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/driver/driver_interface/sdio
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/driver/device_interface/sdio/: rsi_sdio_frame_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_mem_rd_wr.c rsi_sdio_reg_rd_wr.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/driver/driver_interface/spi
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/driver/device_interface/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/driver/driver_interface/uart
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/driver/device_interface/uart/: rsi_uart.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/logging
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/logging/: sl_app_logging.c sl_fw_logging.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/network/protocols
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/network/protocols/: rsi_dhcp_user_class.c rsi_dns.c rsi_emb_mqtt_client.c rsi_firmware_upgradation.c rsi_ftp.c rsi_http_client.c rsi_http_ota_fw_up.c rsi_mdnsd.c rsi_mqtt_client.c rsi_multicast.c rsi_ota_fw_up.c rsi_pop3_client.c rsi_raw_data.c rsi_smtp_client.c rsi_sntp_client.c rsi_web_socket.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/network/protocols/http_server
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/network/protocols/http_server/: rsi_http_server.c rsi_json_handlers.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/network/protocols/mdnsd_records
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/network/protocols/mdnsd_records/: rsi_mdnsd_records.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/network/socket
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/rtos/freertos_wrapper
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/rtos/freertos_wrapper/: port.c rsi_os_wrapper.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/sapi/wlan
    ../../10_RS9116/SDK_2.8.0.0.45/sapi/wlan/: rsi_wlan_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/third_party/mqtt_client/src/MQTTPacket
    ../../10_RS9116/SDK_2.8.0.0.45/third_party/mqtt_client/src/: MQTT_sapi_wrappers.c MQTTClient.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/third_party/mqtt_client/src/MQTTPacket/src
    ../../10_RS9116/SDK_2.8.0.0.45/third_party/mqtt_client/src/MQTTPacket/src/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.8.0.0.45/third_party/sbc_audio_codec
    ../../10_RS9116/SDK_2.8.0.0.45/third_party/sbc_audio_codec/src/: sbc_analysis.c sbc_dct.c sbc_dct_coeffs.c sbc_enc_bit_alloc_mono.c sbc_enc_bit_alloc_ste.c sbc_enc_coeffs.c sbc_encoder.c sbc_packing.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/hal
    ../../10_RS9116/SDK_2.9.1.17/hal/: rsi_hal_mcu_com_port.c rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_hal_timer.c sl_hal_mcu_logging.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/bluetooth
    ../../10_RS9116/SDK_2.9.1.17/sapi/bluetooth/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_bt_a2dp_apis.c rsi_bt_avrcp_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_sbc_codec.c rsi_bt_spp_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/common
    ../../10_RS9116/SDK_2.9.1.17/sapi/common/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_common_apis.c rsi_device_init_apis.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/crypto
    ../../10_RS9116/SDK_2.9.1.17/sapi/crypto/: rsi_crypto.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/driver
    ../../10_RS9116/SDK_2.9.1.17/sapi/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_events_rom.c rsi_iap.c rsi_nwk.c rsi_nwk_rom.c rsi_os_none.c rsi_pkt_mgmt.c rsi_pkt_mgmt_rom.c rsi_queue.c rsi_queue_rom.c rsi_scheduler.c rsi_scheduler_rom.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_utils_rom.c rsi_wlan.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/driver/device_interface/sdio
    ../../10_RS9116/SDK_2.9.1.17/sapi/driver/device_interface/sdio/: rsi_sdio_frame_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_mem_rd_wr.c rsi_sdio_reg_rd_wr.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/driver/device_interface/spi
    ../../10_RS9116/SDK_2.9.1.17/sapi/driver/device_interface/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/driver/device_interface/uart
    ../../10_RS9116/SDK_2.9.1.17/sapi/driver/device_interface/uart/: rsi_uart.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/logging
    ../../10_RS9116/SDK_2.9.1.17/sapi/logging/: sl_app_logging.c sl_fw_logging.c sleep_wakeup_logging.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/network/protocols
    ../../10_RS9116/SDK_2.9.1.17/sapi/network/protocols/: rsi_dhcp_user_class.c rsi_dns.c rsi_emb_mqtt_client.c rsi_firmware_upgradation.c rsi_ftp.c rsi_http_client.c rsi_http_ota_fw_up.c rsi_mdnsd.c rsi_mqtt_client.c rsi_multicast.c rsi_ota_fw_up.c rsi_pop3_client.c rsi_raw_data.c rsi_smtp_client.c rsi_sntp_client.c rsi_web_socket.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/network/protocols/http_server
    ../../10_RS9116/SDK_2.9.1.17/sapi/network/protocols/http_server/: rsi_http_server.c rsi_json_handlers.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/network/protocols/mdnsd_records
    ../../10_RS9116/SDK_2.9.1.17/sapi/network/protocols/mdnsd_records/: rsi_mdnsd_records.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/network/socket
    ../../10_RS9116/SDK_2.9.1.17/sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/rtos/freertos_wrapper
    ../../10_RS9116/SDK_2.9.1.17/sapi/rtos/freertos_wrapper/: rsi_os_wrapper.c
  group Middlewares/FreeRTOS/RS9116/SDK_2.9.1.17/sapi/wlan
    ../../10_RS9116/SDK_2.9.1.17/sapi/wlan/: rsi_wlan_apis.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/zlib
    ../../13_zlib/: adler32.c compress.c crc32.c deflate.c gzclose.c gzlib.c gzread.c gzwrite.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
