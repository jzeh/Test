# IAR project EVCD_Test_Appli.ewp, settings and files
configuration EVCD_Test_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3I8 ST STM32H7S3I8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx
  ICCARM.CCIncludePath2: ../../Appli/Core/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include; ../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../Drivers/CMSIS/RTOS2/Include; ../../Appli/USB_DEVICE/App; ../../Appli/USB_DEVICE/Target; ../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../Appli/FATFS/Target; ../../Appli/FATFS/App; ../../Middlewares/Third_Party/FatFs/source; ../../Middlewares/Third_Party/FatFs/source/drivers/template; ../../Common/Inc; ../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../Appli/Core/Inc; ../../Appli/FATFS/Target; ../../Appli/FATFS/App; ../../Appli/USB_DEVICE/App; ../../Appli/USB_DEVICE/Target; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../Drivers/CMSIS/RTOS2/Include; ../../Middlewares/Third_Party/FatFs/source; ../../Middlewares/Third_Party/FatFs/source/drivers/template; ../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: EVCD_Test_Appli.bin
  ILINK.IlinkOutputFile: EVCD_Test_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_ROMxspi1_slot0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Appli/Common
    ../../Common/Src/: fw_backup_sram.c fw_crc32.c fw_update.c
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: freertos.c main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c stm32h7rsxx_it.c
  group Application/User/Appli/FATFS/App
    ../../Appli/FATFS/App/: fatfs.c user_diskio.c
  group Application/User/Appli/Function
    ../../Appli/Function/Src/: cli-bsa.c cli-plc.c git-ble.c git-comm.c git-functionlist-fwupdate.c git-functionlist.c git-protocol.c led-indicator.c sys-emmc.c sys-main.c task-aim.c task-bsa.c task-can.c task-cli.c task-hwcontrol.c task-lcd.c task-plc.c task-sensor.c test-blebulk.c
  group Application/User/Appli/USB_DEVICE/App
    ../../Appli/USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/Appli/USB_DEVICE/Target
    ../../Appli/USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_fdcan.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_mmc.c stm32h7rsxx_hal_mmc_ex.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_dlyb.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_ll_usb.c
  group Middlewares/FatFs
    ../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffsystem_cmsis_os.c ffunicode.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c mpu_wrappers_v2.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STM32_USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
