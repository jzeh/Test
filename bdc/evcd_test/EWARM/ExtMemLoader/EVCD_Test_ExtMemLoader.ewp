# IAR project EVCD_Test_ExtMemLoader.ewp, settings and files
configuration EVCD_Test_ExtMemLoader (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3I8 ST STM32H7S3I8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx; STM32_EXTMEMLOADER_STM32CUBETARGET
  ICCARM.CCIncludePath2: ../../ExtMemLoader/Core/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Middlewares/ST/STM32_ExtMem_Loader/core; ../../Middlewares/ST/STM32_ExtMem_Loader/EWARM; ../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM; ../../Middlewares/ST/STM32_ExtMem_Loader/STM32Cube; ../../Middlewares/ST/STM32_ExtMem_Manager; ../../Middlewares/ST/STM32_ExtMem_Manager/sal; ../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; ../../Middlewares/ST/STM32_ExtMem_Manager/psram; ../../Middlewares/ST/STM32_ExtMem_Manager/sdcard; ../../Middlewares/ST/STM32_ExtMem_Manager/user; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32_EXTMEMLOADER_STM32CUBETARGET
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: EVCD_Test_ExtMemLoader.hex
  ILINK.IlinkOutputFile: EVCD_Test_ExtMemLoader.out
  ILINK.IlinkIcfFile: stm32h7rsxx_extmemloader_stm32cube.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User/ExtMemLoader/Core
    ../../ExtMemLoader/Core/Src/: extmem_manager.c stm32h7rsxx_hal_msp.c extmemloader_init.c
  group Drivers/CMSIS
    ../../ExtMemLoader/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c stm32_sal_sd.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
  group Middlewares/STM32_ExtMem_Loader
    ../../Middlewares/ST/STM32_ExtMem_Loader/core/: memory_wrapper.c systick_management.c
    ../../Middlewares/ST/STM32_ExtMem_Loader/EWARM/: flash_loader.c flash_loader_asm.s stm32_flash_wrapper.c
    ../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM/: FlashDev.c FlashPrg.c
    ../../Middlewares/ST/STM32_ExtMem_Loader/STM32Cube/: stm32_device_info.c stm32_loader_api.c
