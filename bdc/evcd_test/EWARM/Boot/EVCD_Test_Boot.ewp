# IAR project EVCD_Test_Boot.ewp, settings and files
configuration EVCD_Test_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3I8 ST STM32H7S3I8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx; BOOT_BUILD; FW_UPDATE_ENABLED; EXTMEM_XIP_IMAGE_OFFSET=0x10000; FW_COMPAT_VERBOSE=1
  ICCARM.CCIncludePath2: ../../Boot/Core/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Middlewares/ST/STM32_ExtMem_Manager; ../../Middlewares/ST/STM32_ExtMem_Manager/boot; ../../Middlewares/ST/STM32_ExtMem_Manager/sal; ../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; ../../Middlewares/ST/STM32_ExtMem_Manager/psram; ../../Middlewares/ST/STM32_ExtMem_Manager/sdcard; ../../Middlewares/ST/STM32_ExtMem_Manager/user; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include; ../../Common/Inc; ../../Middlewares/Third_Party/FatFs/source; ..\..\Boot\FATFS\Target
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../Boot/Core/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../Middlewares/ST/STM32_ExtMem_Manager; ../../Middlewares/ST/STM32_ExtMem_Manager/boot; ../../Middlewares/ST/STM32_ExtMem_Manager/sal; ../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; ../../Middlewares/ST/STM32_ExtMem_Manager/psram; ../../Middlewares/ST/STM32_ExtMem_Manager/sdcard; ../../Middlewares/ST/STM32_ExtMem_Manager/user; ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: EVCD_Test_Boot.hex
  ILINK.IlinkOutputFile: EVCD_Test_Boot.out
  ILINK.IlinkIcfFile: stm32h7s3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Boot/Core
    ../../Boot/Core/Src/: main.c extmem_manager.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c
  group Application/User/Boot/Function
    ../../Boot/Core/Src/: boot_diskio.c boot_emmc.c
    ../../Common/Src/: fw_backup_sram.c fw_crc32.c fw_flash_xspi.c fw_slot_manager.c
  group Application/User/Boot/FatFs
    ../../Middlewares/Third_Party/FatFs/source/: ff.c ffunicode.c
  group Drivers/CMSIS
    ../../Boot/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_mmc.c stm32h7rsxx_hal_mmc_ex.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_xip.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c stm32_sal_sd.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    ../../Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
