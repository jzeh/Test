<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Premium_Bootloader\Premium_Bootloader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Premium_Module\Premium_Module.ewp</path>
    </project>
    <batchBuild />
</workspace>
