# IAR project Premium_Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427VI ST STM32F427VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427X; USE_STDPERIPH_DRIVER; FEATURE_BOOTLOADER; USE_FATFILE_SYSTEM; DEBUG_CH_UART7
  ICCARM.CCDiagSuppress: Pa050, Pa039, Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\bulk\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\..\..\Middleware\USB_Devices\inc; ..\..\..\..\..\Autolink_main\inc; ..\..\..\..\..\Common_GIT\inc; ..\..\..\..\..\Common_Premium\inc; ..\..\..\..\..\Common_GIT\SEED256; ..\..\..\..\..\Common_GIT\Penta\dukpt_cli; ..\..\..\..\..\Common_GIT\Penta\crypt; ..\..\..\..\..\Common_GIT\Penta\dukpt_common; ..\..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_Driver; ..\..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_inc; ..\..\..\..\..\Middleware\FileSystem\fat_fs\inc; ..\..\..\..\..\Middleware\FileSystem\little_fs\bd; ..\..\..\..\..\Middleware\FileSystem\little_fs\scripts; ..\..\..\..\..\Utilities\cli\inc; ..\..\..\..\..\Common_GIT\GIT_GPS_LGPL\nmealib-0.5.3\nmealib\include; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\AT32F435VMT7\Libraries\CMSIS\cm4\core_support; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6; ..\..\..\..\..\Common_GIT\SerialFlash; ..\..\..\..\..\Middleware\FileSystem\little_fs; ..\..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AutolinkP_Bootloader.bin
  ILINK.IlinkOutputFile: Premium_Bootloader.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ../../../../../Autolink_main/: main.c
  group Autolink_Bootloader
    ../../../../../Autolink_Bootloader/: GIT_Boot_Util.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/: stm32f4xx_it.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/Cmsis
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427x.s
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group DeviceHAL_GIT/Hal_API
    ../../../../../DeviceHAL_GIT/HAL_API/: HalHandler.c
  group DeviceHAL_GIT/Hal_API/Hal_Driver
    ../../../../../DeviceHAL_GIT/HAL_API/Hal_Driver/: HalFlashDriver.c HalGpioDriver.c HalLedDriver.c HalMiscDriver.c HalRccDriver.c HalSPIDriver.c HalTimerDriver.c HalUartDriver.c
