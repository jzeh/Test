# IAR project Premium_Module.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427VI ST STM32F427VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427X; USE_STDPERIPH_DRIVER; USE_FATFILE_SYSTEM; USE_ALPU_CHIPSET; USE_GPS_LGPL_PARSER; DEBUG_CH_UART7; INITIAL_SETTING_MODEMBAUD; FUEL_LEVEL_CHECK; EXTBOARD_FOTA; USE_GIT_LITTLE_FS; NO_FREEZE_FRAME; QI_DEVELOPE; BLE_NEW_VERSION; RF_COMMON_MODEM; BNCOM; THALES_AGPS; SINGTELUSIM; BNCOM_TEMP; BTWAKETEST; CGW_SECURITY; FEATURE_USE_UART_RX_DMA
  ICCARM.CCDiagSuppress: Pa050, Pe301, Pe867
  ICCARM.CCIncludePath2: ..\..\..\..\..\Autolink_main\inc; ..\..\..\..\..\Autolink_main\ExtendBoard; ..\..\..\..\..\Common_GIT\inc; ..\..\..\..\..\Common_GIT\AesEncrypt_CBC; ..\..\..\..\..\Common_GIT\Penta\crypt; ..\..\..\..\..\Common_GIT\Penta\dukpt_cli; ..\..\..\..\..\Common_GIT\Penta\dukpt_common; ..\..\..\..\..\Common_GIT\Penta\pkcrypt; ..\..\..\..\..\Common_GIT\SEED256; ..\..\..\..\..\Common_GIT\Base64; ..\..\..\..\..\Common_GIT\GIT_GPS_LGPL\nmealib-0.5.3\nmealib\include; ..\..\..\..\..\Common_GIT\SerialFlash; ..\..\..\..\..\Common_Premium\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\bulk\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\Drv\inc; ..\..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_inc; ..\..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_Driver; ..\..\..\..\..\Middleware\3rd_party\Cycur_Library\inc; ..\..\..\..\..\Middleware\FileSystem\fat_fs\inc; ..\..\..\..\..\Middleware\FileSystem\little_fs; ..\..\..\..\..\Middleware\FileSystem\little_fs\bd; ..\..\..\..\..\Middleware\USB_Devices\inc; ..\..\..\..\..\Utilities\cli\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Premium_Module.bin
  ILINK.IlinkOutputFile: Premium_Module.out
  ILINK.IlinkIcfFile: Premium_Module.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Middleware\3rd_party\Copy_Protect\neowine_20141215.a; ..\..\..\..\..\Middleware\3rd_party\Cycur_Library\bin\CycurLIB.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F427X; USE_STDPERIPH_DRIVER; USE_FATFILE_SYSTEM; USE_ALPU_CHIPSET; USE_GPS_LGPL_PARSER; DEBUG_CH_UART7; INITIAL_SETTING_MODEMBAUD; FUEL_LEVEL_CHECK; EXTBOARD_FOTA; USE_GIT_LITTLE_FS; NO_FREEZE_FRAME; QI_DEVELOPE; BLE_NEW_VERSION; RF_COMMON_MODEM; BNCOM; THALES_AGPS; SINGTELUSIM; BNCOM_TEMP; BTWAKETEST; FEATURE_USE_UART_RX_DMA
  ICCARM.CCIncludePath2: ..\..\..\Autolink_main\inc; ..\..\..\Autolink_main\ExtendBoard; ..\..\..\Common_GIT\inc; ..\..\..\Common_GIT\AesEncrypt_CBC; ..\..\..\Common_GIT\Penta\crypt; ..\..\..\Common_GIT\Penta\dukpt_cli; ..\..\..\Common_GIT\Penta\dukpt_common; ..\..\..\Common_GIT\Penta\pkcrypt; ..\..\..\Common_GIT\SEED256; ..\..\..\Common_GIT\Base64; ..\..\..\Common_GIT\GIT_GPS_LGPL\nmealib-0.5.3\nmealib\include; ..\..\..\Common_GIT\SerialFlash; ..\..\..\Common_Premium\inc; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\bulk\inc; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\DeviceHAL_GIT\BoardSupportPackage\STM32F427VIT6\Libraries\Drv\inc; ..\..\..\DeviceHAL_GIT\HAL_API\Hal_inc; ..\..\..\DeviceHAL_GIT\HAL_API\Hal_Driver; ..\..\..\Middleware\3rd_party\Cycur_Library\inc; ..\..\..\Middleware\FileSystem\fat_fs\inc; ..\..\..\Middleware\FileSystem\little_fs; ..\..\..\Middleware\FileSystem\little_fs\bd; ..\..\..\Middleware\USB_Devices\inc; ..\..\..\Utilities\cli\inc
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Premium_Module_Release.bin
  ILINK.IlinkOutputFile: Premium_Molude_Release.out
  ILINK.IlinkIcfFile: Premium_Module_Release.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Middleware\3rd_party\Copy_Protect\neowine_20141215.a; ..\..\..\Middleware\3rd_party\Cycur_Library\bin\CycurLIB.a
  group Autolink_Main
    ../../../../../Autolink_main/: Autolink_Manager.c AutolinkConfig.c CanFD_Controller.c CanFD_Manager.c CanFD_RecvHandler.c DebugHandler.c FOTA_Manager.c HandlerAgps.c HandlerGeofence.c HandlerIpek.c HandlerRsvEngCtrl.c HandlerTracking.c HandlerValet.c HdDebug.c main.c Message_Make.c Message_Manager.c MngMdmFileHandler.c MngModem.c MngModemEvtHandler.c MngQueue.c MngSensor.c MngStorage.c MngSysHandler.c MngSysMsgBtHandler.c MngSysMsgEvtHandler.c MngSysMsgFileHandler.c MngSysMsgHandler.c MngSysSensorHandler.c MngSystem.c MngSystemHdTime.c MngSystemHdUserAction.c MngSystemUtil.c Modem_Manager.c Power_Manager.c UARTDMA_Manager.c
  group Autolink_Main/ExtendBoard
    ../../../../../Autolink_main/ExtendBoard/: SysPsExtend.c SysPsExtendHdControl.c SysPsExtendHdEvent.c
  group Autolink_Main/OBD
    ../../../../../Autolink_main/: OBD_CGW_Security.c OBD_Controller.c OBD_Controller_Get.c OBD_Manager.c
  group Common_GIT
    ../../../../../Common_GIT/: GIT_AesEncrypt.c GIT_BluetoothLowEnergy.c GIT_Boot_Util.c GIT_CanParsingProc.c GIT_Gps.c GIT_InterProtocol.c GIT_OemInterface.c GIT_Util.c GIT_VCI.c SysHalFileSystem.c
  group Common_GIT/Base64
    ../../../../../Common_GIT/Base64/: GIT_base64.c
  group Common_GIT/GIT_GPS_LPGL
    ../../../../../Common_GIT/GIT_GPS_LGPL/nmealib-0.5.3/nmealib/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group Common_GIT/Penta/crypt
    ../../../../../Common_GIT/Penta/crypt/: aes.c base64_penta.c des.c dukpt_algo.c entropy.c hight.c hmac.c hmac_drbg.c hmac_sha256.c rng.c seed.c sha256.c x9tr31.c
  group Common_GIT/Penta/dukpt_cli
    ../../../../../Common_GIT/Penta/dukpt_cli/: dukpt_cli.c
  group Common_GIT/Penta/pkcrypt
    ../../../../../Common_GIT/Penta/pkcrypt/: damo_pkcrypt.c ps_asn1parse.c ps_base64.c ps_bignum.c ps_md.c ps_md_wrap.c ps_oid.c ps_pem.c ps_pk.c ps_pk_wrap.c ps_pkparse.c ps_rsa.c
  group Common_GIT/Penta/test
    ../../../../../Common_GIT/Penta/test/: aestest.c base64test.c dukpttest_cli.c
  group Common_GIT/SEED256
    ../../../../../Common_GIT/SEED256/: KISA_SEED_ECB.c SEED_256_KISA.c
  group Common_GIT/SerialFlash
    ../../../../../Common_GIT/SerialFlash/: SPIDriverMicron.c
  group Common_Premium
    ../../../../../Common_Premium/: Modem_comm.c Share_InterFunction.c
  group DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/: at32f435_437_clock.c at32f435_437_int.c
  group DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/AT32F43x_StdPeriph_Driver
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/AT32F43x_StdPeriph_Driver/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/Cmsis
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/CMSIS/cm4/device_support/startup/iar/: startup_at32f435_437.s
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/CMSIS/cm4/device_support/: system_at32f435_437.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/: stm32f4xx_it.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/Cmsis
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427x.s
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/BULK
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/bulk/src/: usbd_bulk_core.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/CDC
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/MSC
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Core
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_OTG_Driver
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c usb_otg.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DeviceHAL_GIT/Hal_API
    ../../../../../DeviceHAL_GIT/HAL_API/: HalHandler.c
  group DeviceHAL_GIT/Hal_API/Hal_Driver
    ../../../../../DeviceHAL_GIT/HAL_API/Hal_Driver/: HalAdcDriver.c HalCanDriver.c HalDmaDriver.c HalExIntDriver.c HalFlashDriver.c HalGpioDriver.c HalI2CDriver.c HalLedDriver.c HalMiscDriver.c HalPowerDriver.c HalRccDriver.c HalRtcDriver.c HalSPIDriver.c HalTimerDriver.c HalTimerWatchDoc.c HalUartDriver.c
  group Middleware/FileSystem/FAT_FS
    ../../../../../Middleware/FileSystem/fat_fs/: diskio.c fattime.c ff.c
  group Middleware/FileSystem/FAT_FS/Option
    ../../../../../Middleware/FileSystem/fat_fs/option/: ccsbcs.c
  group Middleware/FileSystem/Little_FS
    ../../../../../Middleware/FileSystem/little_fs/: lfs.c lfs_util.c LfsPorting.c
  group Middleware/FileSystem/Little_FS/BD
    ../../../../../Middleware/FileSystem/little_fs/bd/: lfs_filebd.c lfs_rambd.c lfs_testbd.c
  group Middleware/USB_Devices
    ../../../../../Middleware/USB_Devices/: usb_bsp.c usb_trx.c usbd_bulk_desc.c usbd_cdc_vcp.c usbd_msc_desc.c usbd_storage_msd.c usbd_usr.c usbd_vcp_desc.c
  group Utilities/CLI
    ../../../../../Utilities/cli/: app_cli.c cli.c uartcli.c
