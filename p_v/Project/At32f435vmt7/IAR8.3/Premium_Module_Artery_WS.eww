<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Premium_Bootloader_Artery\Premium_Bootloader_Artery.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Premium_Module_Artery\ELS\Premium_Module_Artery_ELS.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Premium_Module_Artery\PLS\Premium_Module_Artery_PLS.ewp</path>
    </project>
    <batchBuild />
</workspace>
