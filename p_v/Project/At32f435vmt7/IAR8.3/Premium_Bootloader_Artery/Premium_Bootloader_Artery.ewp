# IAR project Premium_Bootloader_Artery.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F435VMT7_v2 ArteryTek -AT32F435VMT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F435VMT7; USE_STDPERIPH_DRIVER; FEATURE_BOOTLOADER; DEBUG_CH_UART7
  ICCARM.CCDiagSuppress: Pa050, Pe301, Pe867
  ICCARM.CCIncludePath2: ..\..\..\..\Autolink_main\inc; ..\..\..\..\Autolink_main\ExtendBoard; ..\..\..\..\Common_GIT\inc; ..\..\..\..\Common_GIT\AesEncrypt_CBC; ..\..\..\..\Common_GIT\Penta\crypt; ..\..\..\..\Common_GIT\Penta\dukpt_cli; ..\..\..\..\Common_GIT\Penta\dukpt_common; ..\..\..\..\Common_GIT\Penta\pkcrypt; ..\..\..\..\Common_GIT\SEED256; ..\..\..\..\Common_GIT\Base64; ..\..\..\..\Common_GIT\GIT_GPS_LGPL\nmealib-0.5.3\nmealib\include; ..\..\..\..\Common_GIT\SerialFlash; ..\..\..\..\Common_Premium\inc; ..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\AT32F435VMT7; ..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\AT32F435VMT7\Libraries\AT32F43x_StdPeriph_Driver\inc; ..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\AT32F435VMT7\Libraries\CMSIS\cm4\device_support; ..\..\..\..\Middleware\3rd_party\Cycur_Library\inc; ..\..\..\..\Middleware\FileSystem\fat_fs\inc; ..\..\..\..\Middleware\FileSystem\little_fs; ..\..\..\..\Middleware\FileSystem\little_fs\bd; ..\..\..\..\Middleware\USB_Devices\inc; ..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_inc; ..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_Driver; ..\..\..\..\Middleware\3rd_party\Cycur_Library\inc; ..\..\..\..\Middleware\FileSystem\fat_fs\inc; ..\..\..\..\Middleware\FileSystem\little_fs; ..\..\..\..\Middleware\FileSystem\little_fs\bd; ..\..\..\..\Middleware\USB_Devices\inc; ..\..\..\..\Utilities\cli\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ArteryP_Bootloader_V5xxx.bin
  ILINK.IlinkOutputFile: ArteryP_Bootloader_V5xxx.out
  ILINK.IlinkIcfFile: Premium_Bootloader_Artery.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../../../../Autolink_main/: main.c
  group Autolink_Bootloader
    ../../../../Autolink_Bootloader/: GIT_Boot_Util.c
  group DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7
    ../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/: at32f435_437_int.c
  group DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/AT32F43x_StdPeriph_Driver
    ../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/AT32F43x_StdPeriph_Driver/src/: at32f435_437_crm.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c
  group DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/Cmsis
    ../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/CMSIS/cm4/device_support/startup/iar/: startup_at32f435_437.s
    ../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/CMSIS/cm4/device_support/: system_at32f435_437.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/: stm32f4xx_initial.c stm32f4xx_it.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/Cmsis
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427x.s
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/BULK
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/bulk/src/: usbd_bulk_core.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/CDC
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/MSC
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Core
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_OTG_Driver
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c usb_otg.c
  group DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../DeviceHAL_GIT/BoardSupportPackage/STM32F427VIT6/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DeviceHAL_GIT/Hal_API
    ../../../../DeviceHAL_GIT/HAL_API/: HalHandler.c
  group DeviceHAL_GIT/Hal_API/Hal_Driver
    ../../../../DeviceHAL_GIT/HAL_API/Hal_Driver/: HalFlashDriver.c HalGpioDriver.c HalLedDriver.c HalMiscDriver.c HalRccDriver.c HalSPIDriver.c HalTimerDriver.c HalUartDriver.c
