<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Premium_Bootloader_Artery.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Premium_Module_Artery\Premium_Module_Artery.ewp</path>
  </project>
  <batchBuild/>
</workspace>


