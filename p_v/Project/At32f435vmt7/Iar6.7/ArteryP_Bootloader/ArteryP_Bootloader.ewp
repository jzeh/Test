# IAR project ArteryP_Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F435VMT7_v2 ArteryTek -AT32F435VMT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F435VMT7; USE_STDPERIPH_DRIVER; FEATURE_BOOTLOADER; DEBUG_CH_UART7
  ICCARM.CCDiagSuppress: Pa050, Pe301, Pe867
  ICCARM.CCIncludePath2: ..\..\..\..\Autolink_main\inc; ..\..\..\..\Autolink_main\ExtendBoard; ..\..\..\..\Common_GIT\inc; ..\..\..\..\Common_GIT\AesEncrypt_CBC; ..\..\..\..\Common_GIT\Penta\crypt; ..\..\..\..\Common_GIT\Penta\dukpt_cli; ..\..\..\..\Common_GIT\Penta\dukpt_common; ..\..\..\..\Common_GIT\Penta\pkcrypt; ..\..\..\..\Common_GIT\SEED256; ..\..\..\..\Common_GIT\Base64; ..\..\..\..\Common_GIT\GIT_GPS_LGPL\nmealib-0.5.3\nmealib\include; ..\..\..\..\Common_GIT\SerialFlash; ..\..\..\..\Common_Premium\inc; ..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\AT32F435VMT7; ..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\AT32F435VMT7\Libraries\AT32F43x_StdPeriph_Driver\inc; ..\..\..\..\DeviceHAL_GIT\BoardSupportPackage\AT32F435VMT7\Libraries\CMSIS\cm4\device_support; ..\..\..\..\Middleware\3rd_party\Cycur_Library\inc; ..\..\..\..\Middleware\FileSystem\fat_fs\inc; ..\..\..\..\Middleware\FileSystem\little_fs; ..\..\..\..\Middleware\FileSystem\little_fs\bd; ..\..\..\..\Middleware\USB_Devices\inc; ..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_inc; ..\..\..\..\DeviceHAL_GIT\HAL_API\Hal_Driver; ..\..\..\..\Middleware\3rd_party\Cycur_Library\inc; ..\..\..\..\Middleware\FileSystem\fat_fs\inc; ..\..\..\..\Middleware\FileSystem\little_fs; ..\..\..\..\Middleware\FileSystem\little_fs\bd; ..\..\..\..\Middleware\USB_Devices\inc; ..\..\..\..\Utilities\cli\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ArteryP_Bootloader_V50xx.bin
  ILINK.IlinkOutputFile: ArteryP_Bootloader.out
  ILINK.IlinkIcfFile: ArteryP_Bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../Autolink_main/: main.c
  group Autolink_Bootloader
    ../../../../Autolink_Bootloader/: GIT_Boot_Util.c
  group DeviceHal_GIT/BoardSupportPackage/AT32F435VMT7
    ../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/: at32f435_437_int.c
  group DeviceHal_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/AT32F43x_StdPeriph_Driver
    ../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/AT32F43x_StdPeriph_Driver/src/: at32f435_437_crm.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c
  group DeviceHal_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/CMSIS
    ../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/CMSIS/cm4/device_support/startup/iar/: startup_at32f435_437.s
    ../../../../DeviceHAL_GIT/BoardSupportPackage/AT32F435VMT7/Libraries/CMSIS/cm4/device_support/: system_at32f435_437.c
  group DeviceHal_GIT/HAL_API
    ../../../../DeviceHAL_GIT/HAL_API/: HalHandler.c
  group DeviceHal_GIT/HAL_API/HAL_Driver
    ../../../../DeviceHAL_GIT/HAL_API/Hal_Driver/: HalFlashDriver.c HalGpioDriver.c HalLedDriver.c HalMiscDriver.c HalRccDriver.c HalTimerDriver.c HalUartDriver.c
